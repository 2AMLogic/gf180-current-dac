v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {bias.sym} 0 0 0 0 {name=xbias}
N -80 10 -100 10 {}
C {devices/lab_pin.sym} -100 10 0 0 {name=l1 sig_type=std_logic lab=iref}
N -80 30 -100 30 {}
C {devices/lab_pin.sym} -100 30 0 0 {name=l2 sig_type=std_logic lab=vss}
N 80 10 100 10 {}
C {devices/lab_pin.sym} 100 10 2 0 {name=l3 sig_type=std_logic lab=vbn}
C {driver.sym} 600 300 0 0 {name=xdrv_t0}
N 520 310 500 310 {}
C {devices/lab_pin.sym} 500 310 0 0 {name=l4 sig_type=std_logic lab=t0}
N 520 330 500 330 {}
C {devices/lab_pin.sym} 500 330 0 0 {name=l5 sig_type=std_logic lab=vdd}
N 520 350 500 350 {}
C {devices/lab_pin.sym} 500 350 0 0 {name=l6 sig_type=std_logic lab=vss}
N 680 310 700 310 {}
C {devices/lab_pin.sym} 700 310 2 0 {name=l7 sig_type=std_logic lab=sp_t0}
N 680 330 700 330 {}
C {devices/lab_pin.sym} 700 330 2 0 {name=l8 sig_type=std_logic lab=sn_t0}
C {elem_16.sym} 600 500 0 0 {name=xel_t0}
N 520 510 500 510 {}
C {devices/lab_pin.sym} 500 510 0 0 {name=l9 sig_type=std_logic lab=vbn}
N 520 530 500 530 {}
C {devices/lab_pin.sym} 500 530 0 0 {name=l10 sig_type=std_logic lab=iref}
N 520 550 500 550 {}
C {devices/lab_pin.sym} 500 550 0 0 {name=l11 sig_type=std_logic lab=sp_t0}
N 520 570 500 570 {}
C {devices/lab_pin.sym} 500 570 0 0 {name=l12 sig_type=std_logic lab=sn_t0}
N 520 590 500 590 {}
C {devices/lab_pin.sym} 500 590 0 0 {name=l13 sig_type=std_logic lab=vss}
N 520 610 500 610 {}
C {devices/lab_pin.sym} 500 610 0 0 {name=l14 sig_type=std_logic lab=outp}
N 520 630 500 630 {}
C {devices/lab_pin.sym} 500 630 0 0 {name=l15 sig_type=std_logic lab=outn}
C {driver.sym} 1300 300 0 0 {name=xdrv_t1}
N 1220 310 1200 310 {}
C {devices/lab_pin.sym} 1200 310 0 0 {name=l16 sig_type=std_logic lab=t1}
N 1220 330 1200 330 {}
C {devices/lab_pin.sym} 1200 330 0 0 {name=l17 sig_type=std_logic lab=vdd}
N 1220 350 1200 350 {}
C {devices/lab_pin.sym} 1200 350 0 0 {name=l18 sig_type=std_logic lab=vss}
N 1380 310 1400 310 {}
C {devices/lab_pin.sym} 1400 310 2 0 {name=l19 sig_type=std_logic lab=sp_t1}
N 1380 330 1400 330 {}
C {devices/lab_pin.sym} 1400 330 2 0 {name=l20 sig_type=std_logic lab=sn_t1}
C {elem_16.sym} 1300 500 0 0 {name=xel_t1}
N 1220 510 1200 510 {}
C {devices/lab_pin.sym} 1200 510 0 0 {name=l21 sig_type=std_logic lab=vbn}
N 1220 530 1200 530 {}
C {devices/lab_pin.sym} 1200 530 0 0 {name=l22 sig_type=std_logic lab=iref}
N 1220 550 1200 550 {}
C {devices/lab_pin.sym} 1200 550 0 0 {name=l23 sig_type=std_logic lab=sp_t1}
N 1220 570 1200 570 {}
C {devices/lab_pin.sym} 1200 570 0 0 {name=l24 sig_type=std_logic lab=sn_t1}
N 1220 590 1200 590 {}
C {devices/lab_pin.sym} 1200 590 0 0 {name=l25 sig_type=std_logic lab=vss}
N 1220 610 1200 610 {}
C {devices/lab_pin.sym} 1200 610 0 0 {name=l26 sig_type=std_logic lab=outp}
N 1220 630 1200 630 {}
C {devices/lab_pin.sym} 1200 630 0 0 {name=l27 sig_type=std_logic lab=outn}
C {driver.sym} 2000 300 0 0 {name=xdrv_t2}
N 1920 310 1900 310 {}
C {devices/lab_pin.sym} 1900 310 0 0 {name=l28 sig_type=std_logic lab=t2}
N 1920 330 1900 330 {}
C {devices/lab_pin.sym} 1900 330 0 0 {name=l29 sig_type=std_logic lab=vdd}
N 1920 350 1900 350 {}
C {devices/lab_pin.sym} 1900 350 0 0 {name=l30 sig_type=std_logic lab=vss}
N 2080 310 2100 310 {}
C {devices/lab_pin.sym} 2100 310 2 0 {name=l31 sig_type=std_logic lab=sp_t2}
N 2080 330 2100 330 {}
C {devices/lab_pin.sym} 2100 330 2 0 {name=l32 sig_type=std_logic lab=sn_t2}
C {elem_16.sym} 2000 500 0 0 {name=xel_t2}
N 1920 510 1900 510 {}
C {devices/lab_pin.sym} 1900 510 0 0 {name=l33 sig_type=std_logic lab=vbn}
N 1920 530 1900 530 {}
C {devices/lab_pin.sym} 1900 530 0 0 {name=l34 sig_type=std_logic lab=iref}
N 1920 550 1900 550 {}
C {devices/lab_pin.sym} 1900 550 0 0 {name=l35 sig_type=std_logic lab=sp_t2}
N 1920 570 1900 570 {}
C {devices/lab_pin.sym} 1900 570 0 0 {name=l36 sig_type=std_logic lab=sn_t2}
N 1920 590 1900 590 {}
C {devices/lab_pin.sym} 1900 590 0 0 {name=l37 sig_type=std_logic lab=vss}
N 1920 610 1900 610 {}
C {devices/lab_pin.sym} 1900 610 0 0 {name=l38 sig_type=std_logic lab=outp}
N 1920 630 1900 630 {}
C {devices/lab_pin.sym} 1900 630 0 0 {name=l39 sig_type=std_logic lab=outn}
C {driver.sym} 2700 300 0 0 {name=xdrv_t3}
N 2620 310 2600 310 {}
C {devices/lab_pin.sym} 2600 310 0 0 {name=l40 sig_type=std_logic lab=t3}
N 2620 330 2600 330 {}
C {devices/lab_pin.sym} 2600 330 0 0 {name=l41 sig_type=std_logic lab=vdd}
N 2620 350 2600 350 {}
C {devices/lab_pin.sym} 2600 350 0 0 {name=l42 sig_type=std_logic lab=vss}
N 2780 310 2800 310 {}
C {devices/lab_pin.sym} 2800 310 2 0 {name=l43 sig_type=std_logic lab=sp_t3}
N 2780 330 2800 330 {}
C {devices/lab_pin.sym} 2800 330 2 0 {name=l44 sig_type=std_logic lab=sn_t3}
C {elem_16.sym} 2700 500 0 0 {name=xel_t3}
N 2620 510 2600 510 {}
C {devices/lab_pin.sym} 2600 510 0 0 {name=l45 sig_type=std_logic lab=vbn}
N 2620 530 2600 530 {}
C {devices/lab_pin.sym} 2600 530 0 0 {name=l46 sig_type=std_logic lab=iref}
N 2620 550 2600 550 {}
C {devices/lab_pin.sym} 2600 550 0 0 {name=l47 sig_type=std_logic lab=sp_t3}
N 2620 570 2600 570 {}
C {devices/lab_pin.sym} 2600 570 0 0 {name=l48 sig_type=std_logic lab=sn_t3}
N 2620 590 2600 590 {}
C {devices/lab_pin.sym} 2600 590 0 0 {name=l49 sig_type=std_logic lab=vss}
N 2620 610 2600 610 {}
C {devices/lab_pin.sym} 2600 610 0 0 {name=l50 sig_type=std_logic lab=outp}
N 2620 630 2600 630 {}
C {devices/lab_pin.sym} 2600 630 0 0 {name=l51 sig_type=std_logic lab=outn}
C {driver.sym} 3400 300 0 0 {name=xdrv_t4}
N 3320 310 3300 310 {}
C {devices/lab_pin.sym} 3300 310 0 0 {name=l52 sig_type=std_logic lab=t4}
N 3320 330 3300 330 {}
C {devices/lab_pin.sym} 3300 330 0 0 {name=l53 sig_type=std_logic lab=vdd}
N 3320 350 3300 350 {}
C {devices/lab_pin.sym} 3300 350 0 0 {name=l54 sig_type=std_logic lab=vss}
N 3480 310 3500 310 {}
C {devices/lab_pin.sym} 3500 310 2 0 {name=l55 sig_type=std_logic lab=sp_t4}
N 3480 330 3500 330 {}
C {devices/lab_pin.sym} 3500 330 2 0 {name=l56 sig_type=std_logic lab=sn_t4}
C {elem_16.sym} 3400 500 0 0 {name=xel_t4}
N 3320 510 3300 510 {}
C {devices/lab_pin.sym} 3300 510 0 0 {name=l57 sig_type=std_logic lab=vbn}
N 3320 530 3300 530 {}
C {devices/lab_pin.sym} 3300 530 0 0 {name=l58 sig_type=std_logic lab=iref}
N 3320 550 3300 550 {}
C {devices/lab_pin.sym} 3300 550 0 0 {name=l59 sig_type=std_logic lab=sp_t4}
N 3320 570 3300 570 {}
C {devices/lab_pin.sym} 3300 570 0 0 {name=l60 sig_type=std_logic lab=sn_t4}
N 3320 590 3300 590 {}
C {devices/lab_pin.sym} 3300 590 0 0 {name=l61 sig_type=std_logic lab=vss}
N 3320 610 3300 610 {}
C {devices/lab_pin.sym} 3300 610 0 0 {name=l62 sig_type=std_logic lab=outp}
N 3320 630 3300 630 {}
C {devices/lab_pin.sym} 3300 630 0 0 {name=l63 sig_type=std_logic lab=outn}
C {driver.sym} 4100 300 0 0 {name=xdrv_t5}
N 4020 310 4000 310 {}
C {devices/lab_pin.sym} 4000 310 0 0 {name=l64 sig_type=std_logic lab=t5}
N 4020 330 4000 330 {}
C {devices/lab_pin.sym} 4000 330 0 0 {name=l65 sig_type=std_logic lab=vdd}
N 4020 350 4000 350 {}
C {devices/lab_pin.sym} 4000 350 0 0 {name=l66 sig_type=std_logic lab=vss}
N 4180 310 4200 310 {}
C {devices/lab_pin.sym} 4200 310 2 0 {name=l67 sig_type=std_logic lab=sp_t5}
N 4180 330 4200 330 {}
C {devices/lab_pin.sym} 4200 330 2 0 {name=l68 sig_type=std_logic lab=sn_t5}
C {elem_16.sym} 4100 500 0 0 {name=xel_t5}
N 4020 510 4000 510 {}
C {devices/lab_pin.sym} 4000 510 0 0 {name=l69 sig_type=std_logic lab=vbn}
N 4020 530 4000 530 {}
C {devices/lab_pin.sym} 4000 530 0 0 {name=l70 sig_type=std_logic lab=iref}
N 4020 550 4000 550 {}
C {devices/lab_pin.sym} 4000 550 0 0 {name=l71 sig_type=std_logic lab=sp_t5}
N 4020 570 4000 570 {}
C {devices/lab_pin.sym} 4000 570 0 0 {name=l72 sig_type=std_logic lab=sn_t5}
N 4020 590 4000 590 {}
C {devices/lab_pin.sym} 4000 590 0 0 {name=l73 sig_type=std_logic lab=vss}
N 4020 610 4000 610 {}
C {devices/lab_pin.sym} 4000 610 0 0 {name=l74 sig_type=std_logic lab=outp}
N 4020 630 4000 630 {}
C {devices/lab_pin.sym} 4000 630 0 0 {name=l75 sig_type=std_logic lab=outn}
C {driver.sym} 4800 300 0 0 {name=xdrv_t6}
N 4720 310 4700 310 {}
C {devices/lab_pin.sym} 4700 310 0 0 {name=l76 sig_type=std_logic lab=t6}
N 4720 330 4700 330 {}
C {devices/lab_pin.sym} 4700 330 0 0 {name=l77 sig_type=std_logic lab=vdd}
N 4720 350 4700 350 {}
C {devices/lab_pin.sym} 4700 350 0 0 {name=l78 sig_type=std_logic lab=vss}
N 4880 310 4900 310 {}
C {devices/lab_pin.sym} 4900 310 2 0 {name=l79 sig_type=std_logic lab=sp_t6}
N 4880 330 4900 330 {}
C {devices/lab_pin.sym} 4900 330 2 0 {name=l80 sig_type=std_logic lab=sn_t6}
C {elem_16.sym} 4800 500 0 0 {name=xel_t6}
N 4720 510 4700 510 {}
C {devices/lab_pin.sym} 4700 510 0 0 {name=l81 sig_type=std_logic lab=vbn}
N 4720 530 4700 530 {}
C {devices/lab_pin.sym} 4700 530 0 0 {name=l82 sig_type=std_logic lab=iref}
N 4720 550 4700 550 {}
C {devices/lab_pin.sym} 4700 550 0 0 {name=l83 sig_type=std_logic lab=sp_t6}
N 4720 570 4700 570 {}
C {devices/lab_pin.sym} 4700 570 0 0 {name=l84 sig_type=std_logic lab=sn_t6}
N 4720 590 4700 590 {}
C {devices/lab_pin.sym} 4700 590 0 0 {name=l85 sig_type=std_logic lab=vss}
N 4720 610 4700 610 {}
C {devices/lab_pin.sym} 4700 610 0 0 {name=l86 sig_type=std_logic lab=outp}
N 4720 630 4700 630 {}
C {devices/lab_pin.sym} 4700 630 0 0 {name=l87 sig_type=std_logic lab=outn}
C {driver.sym} 5500 300 0 0 {name=xdrv_t7}
N 5420 310 5400 310 {}
C {devices/lab_pin.sym} 5400 310 0 0 {name=l88 sig_type=std_logic lab=t7}
N 5420 330 5400 330 {}
C {devices/lab_pin.sym} 5400 330 0 0 {name=l89 sig_type=std_logic lab=vdd}
N 5420 350 5400 350 {}
C {devices/lab_pin.sym} 5400 350 0 0 {name=l90 sig_type=std_logic lab=vss}
N 5580 310 5600 310 {}
C {devices/lab_pin.sym} 5600 310 2 0 {name=l91 sig_type=std_logic lab=sp_t7}
N 5580 330 5600 330 {}
C {devices/lab_pin.sym} 5600 330 2 0 {name=l92 sig_type=std_logic lab=sn_t7}
C {elem_16.sym} 5500 500 0 0 {name=xel_t7}
N 5420 510 5400 510 {}
C {devices/lab_pin.sym} 5400 510 0 0 {name=l93 sig_type=std_logic lab=vbn}
N 5420 530 5400 530 {}
C {devices/lab_pin.sym} 5400 530 0 0 {name=l94 sig_type=std_logic lab=iref}
N 5420 550 5400 550 {}
C {devices/lab_pin.sym} 5400 550 0 0 {name=l95 sig_type=std_logic lab=sp_t7}
N 5420 570 5400 570 {}
C {devices/lab_pin.sym} 5400 570 0 0 {name=l96 sig_type=std_logic lab=sn_t7}
N 5420 590 5400 590 {}
C {devices/lab_pin.sym} 5400 590 0 0 {name=l97 sig_type=std_logic lab=vss}
N 5420 610 5400 610 {}
C {devices/lab_pin.sym} 5400 610 0 0 {name=l98 sig_type=std_logic lab=outp}
N 5420 630 5400 630 {}
C {devices/lab_pin.sym} 5400 630 0 0 {name=l99 sig_type=std_logic lab=outn}
C {driver.sym} 600 900 0 0 {name=xdrv_t8}
N 520 910 500 910 {}
C {devices/lab_pin.sym} 500 910 0 0 {name=l100 sig_type=std_logic lab=t8}
N 520 930 500 930 {}
C {devices/lab_pin.sym} 500 930 0 0 {name=l101 sig_type=std_logic lab=vdd}
N 520 950 500 950 {}
C {devices/lab_pin.sym} 500 950 0 0 {name=l102 sig_type=std_logic lab=vss}
N 680 910 700 910 {}
C {devices/lab_pin.sym} 700 910 2 0 {name=l103 sig_type=std_logic lab=sp_t8}
N 680 930 700 930 {}
C {devices/lab_pin.sym} 700 930 2 0 {name=l104 sig_type=std_logic lab=sn_t8}
C {elem_16.sym} 600 1100 0 0 {name=xel_t8}
N 520 1110 500 1110 {}
C {devices/lab_pin.sym} 500 1110 0 0 {name=l105 sig_type=std_logic lab=vbn}
N 520 1130 500 1130 {}
C {devices/lab_pin.sym} 500 1130 0 0 {name=l106 sig_type=std_logic lab=iref}
N 520 1150 500 1150 {}
C {devices/lab_pin.sym} 500 1150 0 0 {name=l107 sig_type=std_logic lab=sp_t8}
N 520 1170 500 1170 {}
C {devices/lab_pin.sym} 500 1170 0 0 {name=l108 sig_type=std_logic lab=sn_t8}
N 520 1190 500 1190 {}
C {devices/lab_pin.sym} 500 1190 0 0 {name=l109 sig_type=std_logic lab=vss}
N 520 1210 500 1210 {}
C {devices/lab_pin.sym} 500 1210 0 0 {name=l110 sig_type=std_logic lab=outp}
N 520 1230 500 1230 {}
C {devices/lab_pin.sym} 500 1230 0 0 {name=l111 sig_type=std_logic lab=outn}
C {driver.sym} 1300 900 0 0 {name=xdrv_t9}
N 1220 910 1200 910 {}
C {devices/lab_pin.sym} 1200 910 0 0 {name=l112 sig_type=std_logic lab=t9}
N 1220 930 1200 930 {}
C {devices/lab_pin.sym} 1200 930 0 0 {name=l113 sig_type=std_logic lab=vdd}
N 1220 950 1200 950 {}
C {devices/lab_pin.sym} 1200 950 0 0 {name=l114 sig_type=std_logic lab=vss}
N 1380 910 1400 910 {}
C {devices/lab_pin.sym} 1400 910 2 0 {name=l115 sig_type=std_logic lab=sp_t9}
N 1380 930 1400 930 {}
C {devices/lab_pin.sym} 1400 930 2 0 {name=l116 sig_type=std_logic lab=sn_t9}
C {elem_16.sym} 1300 1100 0 0 {name=xel_t9}
N 1220 1110 1200 1110 {}
C {devices/lab_pin.sym} 1200 1110 0 0 {name=l117 sig_type=std_logic lab=vbn}
N 1220 1130 1200 1130 {}
C {devices/lab_pin.sym} 1200 1130 0 0 {name=l118 sig_type=std_logic lab=iref}
N 1220 1150 1200 1150 {}
C {devices/lab_pin.sym} 1200 1150 0 0 {name=l119 sig_type=std_logic lab=sp_t9}
N 1220 1170 1200 1170 {}
C {devices/lab_pin.sym} 1200 1170 0 0 {name=l120 sig_type=std_logic lab=sn_t9}
N 1220 1190 1200 1190 {}
C {devices/lab_pin.sym} 1200 1190 0 0 {name=l121 sig_type=std_logic lab=vss}
N 1220 1210 1200 1210 {}
C {devices/lab_pin.sym} 1200 1210 0 0 {name=l122 sig_type=std_logic lab=outp}
N 1220 1230 1200 1230 {}
C {devices/lab_pin.sym} 1200 1230 0 0 {name=l123 sig_type=std_logic lab=outn}
C {driver.sym} 2000 900 0 0 {name=xdrv_t10}
N 1920 910 1900 910 {}
C {devices/lab_pin.sym} 1900 910 0 0 {name=l124 sig_type=std_logic lab=t10}
N 1920 930 1900 930 {}
C {devices/lab_pin.sym} 1900 930 0 0 {name=l125 sig_type=std_logic lab=vdd}
N 1920 950 1900 950 {}
C {devices/lab_pin.sym} 1900 950 0 0 {name=l126 sig_type=std_logic lab=vss}
N 2080 910 2100 910 {}
C {devices/lab_pin.sym} 2100 910 2 0 {name=l127 sig_type=std_logic lab=sp_t10}
N 2080 930 2100 930 {}
C {devices/lab_pin.sym} 2100 930 2 0 {name=l128 sig_type=std_logic lab=sn_t10}
C {elem_16.sym} 2000 1100 0 0 {name=xel_t10}
N 1920 1110 1900 1110 {}
C {devices/lab_pin.sym} 1900 1110 0 0 {name=l129 sig_type=std_logic lab=vbn}
N 1920 1130 1900 1130 {}
C {devices/lab_pin.sym} 1900 1130 0 0 {name=l130 sig_type=std_logic lab=iref}
N 1920 1150 1900 1150 {}
C {devices/lab_pin.sym} 1900 1150 0 0 {name=l131 sig_type=std_logic lab=sp_t10}
N 1920 1170 1900 1170 {}
C {devices/lab_pin.sym} 1900 1170 0 0 {name=l132 sig_type=std_logic lab=sn_t10}
N 1920 1190 1900 1190 {}
C {devices/lab_pin.sym} 1900 1190 0 0 {name=l133 sig_type=std_logic lab=vss}
N 1920 1210 1900 1210 {}
C {devices/lab_pin.sym} 1900 1210 0 0 {name=l134 sig_type=std_logic lab=outp}
N 1920 1230 1900 1230 {}
C {devices/lab_pin.sym} 1900 1230 0 0 {name=l135 sig_type=std_logic lab=outn}
C {driver.sym} 2700 900 0 0 {name=xdrv_t11}
N 2620 910 2600 910 {}
C {devices/lab_pin.sym} 2600 910 0 0 {name=l136 sig_type=std_logic lab=t11}
N 2620 930 2600 930 {}
C {devices/lab_pin.sym} 2600 930 0 0 {name=l137 sig_type=std_logic lab=vdd}
N 2620 950 2600 950 {}
C {devices/lab_pin.sym} 2600 950 0 0 {name=l138 sig_type=std_logic lab=vss}
N 2780 910 2800 910 {}
C {devices/lab_pin.sym} 2800 910 2 0 {name=l139 sig_type=std_logic lab=sp_t11}
N 2780 930 2800 930 {}
C {devices/lab_pin.sym} 2800 930 2 0 {name=l140 sig_type=std_logic lab=sn_t11}
C {elem_16.sym} 2700 1100 0 0 {name=xel_t11}
N 2620 1110 2600 1110 {}
C {devices/lab_pin.sym} 2600 1110 0 0 {name=l141 sig_type=std_logic lab=vbn}
N 2620 1130 2600 1130 {}
C {devices/lab_pin.sym} 2600 1130 0 0 {name=l142 sig_type=std_logic lab=iref}
N 2620 1150 2600 1150 {}
C {devices/lab_pin.sym} 2600 1150 0 0 {name=l143 sig_type=std_logic lab=sp_t11}
N 2620 1170 2600 1170 {}
C {devices/lab_pin.sym} 2600 1170 0 0 {name=l144 sig_type=std_logic lab=sn_t11}
N 2620 1190 2600 1190 {}
C {devices/lab_pin.sym} 2600 1190 0 0 {name=l145 sig_type=std_logic lab=vss}
N 2620 1210 2600 1210 {}
C {devices/lab_pin.sym} 2600 1210 0 0 {name=l146 sig_type=std_logic lab=outp}
N 2620 1230 2600 1230 {}
C {devices/lab_pin.sym} 2600 1230 0 0 {name=l147 sig_type=std_logic lab=outn}
C {driver.sym} 3400 900 0 0 {name=xdrv_t12}
N 3320 910 3300 910 {}
C {devices/lab_pin.sym} 3300 910 0 0 {name=l148 sig_type=std_logic lab=t12}
N 3320 930 3300 930 {}
C {devices/lab_pin.sym} 3300 930 0 0 {name=l149 sig_type=std_logic lab=vdd}
N 3320 950 3300 950 {}
C {devices/lab_pin.sym} 3300 950 0 0 {name=l150 sig_type=std_logic lab=vss}
N 3480 910 3500 910 {}
C {devices/lab_pin.sym} 3500 910 2 0 {name=l151 sig_type=std_logic lab=sp_t12}
N 3480 930 3500 930 {}
C {devices/lab_pin.sym} 3500 930 2 0 {name=l152 sig_type=std_logic lab=sn_t12}
C {elem_16.sym} 3400 1100 0 0 {name=xel_t12}
N 3320 1110 3300 1110 {}
C {devices/lab_pin.sym} 3300 1110 0 0 {name=l153 sig_type=std_logic lab=vbn}
N 3320 1130 3300 1130 {}
C {devices/lab_pin.sym} 3300 1130 0 0 {name=l154 sig_type=std_logic lab=iref}
N 3320 1150 3300 1150 {}
C {devices/lab_pin.sym} 3300 1150 0 0 {name=l155 sig_type=std_logic lab=sp_t12}
N 3320 1170 3300 1170 {}
C {devices/lab_pin.sym} 3300 1170 0 0 {name=l156 sig_type=std_logic lab=sn_t12}
N 3320 1190 3300 1190 {}
C {devices/lab_pin.sym} 3300 1190 0 0 {name=l157 sig_type=std_logic lab=vss}
N 3320 1210 3300 1210 {}
C {devices/lab_pin.sym} 3300 1210 0 0 {name=l158 sig_type=std_logic lab=outp}
N 3320 1230 3300 1230 {}
C {devices/lab_pin.sym} 3300 1230 0 0 {name=l159 sig_type=std_logic lab=outn}
C {driver.sym} 4100 900 0 0 {name=xdrv_t13}
N 4020 910 4000 910 {}
C {devices/lab_pin.sym} 4000 910 0 0 {name=l160 sig_type=std_logic lab=t13}
N 4020 930 4000 930 {}
C {devices/lab_pin.sym} 4000 930 0 0 {name=l161 sig_type=std_logic lab=vdd}
N 4020 950 4000 950 {}
C {devices/lab_pin.sym} 4000 950 0 0 {name=l162 sig_type=std_logic lab=vss}
N 4180 910 4200 910 {}
C {devices/lab_pin.sym} 4200 910 2 0 {name=l163 sig_type=std_logic lab=sp_t13}
N 4180 930 4200 930 {}
C {devices/lab_pin.sym} 4200 930 2 0 {name=l164 sig_type=std_logic lab=sn_t13}
C {elem_16.sym} 4100 1100 0 0 {name=xel_t13}
N 4020 1110 4000 1110 {}
C {devices/lab_pin.sym} 4000 1110 0 0 {name=l165 sig_type=std_logic lab=vbn}
N 4020 1130 4000 1130 {}
C {devices/lab_pin.sym} 4000 1130 0 0 {name=l166 sig_type=std_logic lab=iref}
N 4020 1150 4000 1150 {}
C {devices/lab_pin.sym} 4000 1150 0 0 {name=l167 sig_type=std_logic lab=sp_t13}
N 4020 1170 4000 1170 {}
C {devices/lab_pin.sym} 4000 1170 0 0 {name=l168 sig_type=std_logic lab=sn_t13}
N 4020 1190 4000 1190 {}
C {devices/lab_pin.sym} 4000 1190 0 0 {name=l169 sig_type=std_logic lab=vss}
N 4020 1210 4000 1210 {}
C {devices/lab_pin.sym} 4000 1210 0 0 {name=l170 sig_type=std_logic lab=outp}
N 4020 1230 4000 1230 {}
C {devices/lab_pin.sym} 4000 1230 0 0 {name=l171 sig_type=std_logic lab=outn}
C {driver.sym} 4800 900 0 0 {name=xdrv_t14}
N 4720 910 4700 910 {}
C {devices/lab_pin.sym} 4700 910 0 0 {name=l172 sig_type=std_logic lab=t14}
N 4720 930 4700 930 {}
C {devices/lab_pin.sym} 4700 930 0 0 {name=l173 sig_type=std_logic lab=vdd}
N 4720 950 4700 950 {}
C {devices/lab_pin.sym} 4700 950 0 0 {name=l174 sig_type=std_logic lab=vss}
N 4880 910 4900 910 {}
C {devices/lab_pin.sym} 4900 910 2 0 {name=l175 sig_type=std_logic lab=sp_t14}
N 4880 930 4900 930 {}
C {devices/lab_pin.sym} 4900 930 2 0 {name=l176 sig_type=std_logic lab=sn_t14}
C {elem_16.sym} 4800 1100 0 0 {name=xel_t14}
N 4720 1110 4700 1110 {}
C {devices/lab_pin.sym} 4700 1110 0 0 {name=l177 sig_type=std_logic lab=vbn}
N 4720 1130 4700 1130 {}
C {devices/lab_pin.sym} 4700 1130 0 0 {name=l178 sig_type=std_logic lab=iref}
N 4720 1150 4700 1150 {}
C {devices/lab_pin.sym} 4700 1150 0 0 {name=l179 sig_type=std_logic lab=sp_t14}
N 4720 1170 4700 1170 {}
C {devices/lab_pin.sym} 4700 1170 0 0 {name=l180 sig_type=std_logic lab=sn_t14}
N 4720 1190 4700 1190 {}
C {devices/lab_pin.sym} 4700 1190 0 0 {name=l181 sig_type=std_logic lab=vss}
N 4720 1210 4700 1210 {}
C {devices/lab_pin.sym} 4700 1210 0 0 {name=l182 sig_type=std_logic lab=outp}
N 4720 1230 4700 1230 {}
C {devices/lab_pin.sym} 4700 1230 0 0 {name=l183 sig_type=std_logic lab=outn}
C {driver.sym} 5500 900 0 0 {name=xdrv_t15}
N 5420 910 5400 910 {}
C {devices/lab_pin.sym} 5400 910 0 0 {name=l184 sig_type=std_logic lab=t15}
N 5420 930 5400 930 {}
C {devices/lab_pin.sym} 5400 930 0 0 {name=l185 sig_type=std_logic lab=vdd}
N 5420 950 5400 950 {}
C {devices/lab_pin.sym} 5400 950 0 0 {name=l186 sig_type=std_logic lab=vss}
N 5580 910 5600 910 {}
C {devices/lab_pin.sym} 5600 910 2 0 {name=l187 sig_type=std_logic lab=sp_t15}
N 5580 930 5600 930 {}
C {devices/lab_pin.sym} 5600 930 2 0 {name=l188 sig_type=std_logic lab=sn_t15}
C {elem_16.sym} 5500 1100 0 0 {name=xel_t15}
N 5420 1110 5400 1110 {}
C {devices/lab_pin.sym} 5400 1110 0 0 {name=l189 sig_type=std_logic lab=vbn}
N 5420 1130 5400 1130 {}
C {devices/lab_pin.sym} 5400 1130 0 0 {name=l190 sig_type=std_logic lab=iref}
N 5420 1150 5400 1150 {}
C {devices/lab_pin.sym} 5400 1150 0 0 {name=l191 sig_type=std_logic lab=sp_t15}
N 5420 1170 5400 1170 {}
C {devices/lab_pin.sym} 5400 1170 0 0 {name=l192 sig_type=std_logic lab=sn_t15}
N 5420 1190 5400 1190 {}
C {devices/lab_pin.sym} 5400 1190 0 0 {name=l193 sig_type=std_logic lab=vss}
N 5420 1210 5400 1210 {}
C {devices/lab_pin.sym} 5400 1210 0 0 {name=l194 sig_type=std_logic lab=outp}
N 5420 1230 5400 1230 {}
C {devices/lab_pin.sym} 5400 1230 0 0 {name=l195 sig_type=std_logic lab=outn}
C {driver.sym} 600 1500 0 0 {name=xdrv_t16}
N 520 1510 500 1510 {}
C {devices/lab_pin.sym} 500 1510 0 0 {name=l196 sig_type=std_logic lab=t16}
N 520 1530 500 1530 {}
C {devices/lab_pin.sym} 500 1530 0 0 {name=l197 sig_type=std_logic lab=vdd}
N 520 1550 500 1550 {}
C {devices/lab_pin.sym} 500 1550 0 0 {name=l198 sig_type=std_logic lab=vss}
N 680 1510 700 1510 {}
C {devices/lab_pin.sym} 700 1510 2 0 {name=l199 sig_type=std_logic lab=sp_t16}
N 680 1530 700 1530 {}
C {devices/lab_pin.sym} 700 1530 2 0 {name=l200 sig_type=std_logic lab=sn_t16}
C {elem_16.sym} 600 1700 0 0 {name=xel_t16}
N 520 1710 500 1710 {}
C {devices/lab_pin.sym} 500 1710 0 0 {name=l201 sig_type=std_logic lab=vbn}
N 520 1730 500 1730 {}
C {devices/lab_pin.sym} 500 1730 0 0 {name=l202 sig_type=std_logic lab=iref}
N 520 1750 500 1750 {}
C {devices/lab_pin.sym} 500 1750 0 0 {name=l203 sig_type=std_logic lab=sp_t16}
N 520 1770 500 1770 {}
C {devices/lab_pin.sym} 500 1770 0 0 {name=l204 sig_type=std_logic lab=sn_t16}
N 520 1790 500 1790 {}
C {devices/lab_pin.sym} 500 1790 0 0 {name=l205 sig_type=std_logic lab=vss}
N 520 1810 500 1810 {}
C {devices/lab_pin.sym} 500 1810 0 0 {name=l206 sig_type=std_logic lab=outp}
N 520 1830 500 1830 {}
C {devices/lab_pin.sym} 500 1830 0 0 {name=l207 sig_type=std_logic lab=outn}
C {driver.sym} 1300 1500 0 0 {name=xdrv_t17}
N 1220 1510 1200 1510 {}
C {devices/lab_pin.sym} 1200 1510 0 0 {name=l208 sig_type=std_logic lab=t17}
N 1220 1530 1200 1530 {}
C {devices/lab_pin.sym} 1200 1530 0 0 {name=l209 sig_type=std_logic lab=vdd}
N 1220 1550 1200 1550 {}
C {devices/lab_pin.sym} 1200 1550 0 0 {name=l210 sig_type=std_logic lab=vss}
N 1380 1510 1400 1510 {}
C {devices/lab_pin.sym} 1400 1510 2 0 {name=l211 sig_type=std_logic lab=sp_t17}
N 1380 1530 1400 1530 {}
C {devices/lab_pin.sym} 1400 1530 2 0 {name=l212 sig_type=std_logic lab=sn_t17}
C {elem_16.sym} 1300 1700 0 0 {name=xel_t17}
N 1220 1710 1200 1710 {}
C {devices/lab_pin.sym} 1200 1710 0 0 {name=l213 sig_type=std_logic lab=vbn}
N 1220 1730 1200 1730 {}
C {devices/lab_pin.sym} 1200 1730 0 0 {name=l214 sig_type=std_logic lab=iref}
N 1220 1750 1200 1750 {}
C {devices/lab_pin.sym} 1200 1750 0 0 {name=l215 sig_type=std_logic lab=sp_t17}
N 1220 1770 1200 1770 {}
C {devices/lab_pin.sym} 1200 1770 0 0 {name=l216 sig_type=std_logic lab=sn_t17}
N 1220 1790 1200 1790 {}
C {devices/lab_pin.sym} 1200 1790 0 0 {name=l217 sig_type=std_logic lab=vss}
N 1220 1810 1200 1810 {}
C {devices/lab_pin.sym} 1200 1810 0 0 {name=l218 sig_type=std_logic lab=outp}
N 1220 1830 1200 1830 {}
C {devices/lab_pin.sym} 1200 1830 0 0 {name=l219 sig_type=std_logic lab=outn}
C {driver.sym} 2000 1500 0 0 {name=xdrv_t18}
N 1920 1510 1900 1510 {}
C {devices/lab_pin.sym} 1900 1510 0 0 {name=l220 sig_type=std_logic lab=t18}
N 1920 1530 1900 1530 {}
C {devices/lab_pin.sym} 1900 1530 0 0 {name=l221 sig_type=std_logic lab=vdd}
N 1920 1550 1900 1550 {}
C {devices/lab_pin.sym} 1900 1550 0 0 {name=l222 sig_type=std_logic lab=vss}
N 2080 1510 2100 1510 {}
C {devices/lab_pin.sym} 2100 1510 2 0 {name=l223 sig_type=std_logic lab=sp_t18}
N 2080 1530 2100 1530 {}
C {devices/lab_pin.sym} 2100 1530 2 0 {name=l224 sig_type=std_logic lab=sn_t18}
C {elem_16.sym} 2000 1700 0 0 {name=xel_t18}
N 1920 1710 1900 1710 {}
C {devices/lab_pin.sym} 1900 1710 0 0 {name=l225 sig_type=std_logic lab=vbn}
N 1920 1730 1900 1730 {}
C {devices/lab_pin.sym} 1900 1730 0 0 {name=l226 sig_type=std_logic lab=iref}
N 1920 1750 1900 1750 {}
C {devices/lab_pin.sym} 1900 1750 0 0 {name=l227 sig_type=std_logic lab=sp_t18}
N 1920 1770 1900 1770 {}
C {devices/lab_pin.sym} 1900 1770 0 0 {name=l228 sig_type=std_logic lab=sn_t18}
N 1920 1790 1900 1790 {}
C {devices/lab_pin.sym} 1900 1790 0 0 {name=l229 sig_type=std_logic lab=vss}
N 1920 1810 1900 1810 {}
C {devices/lab_pin.sym} 1900 1810 0 0 {name=l230 sig_type=std_logic lab=outp}
N 1920 1830 1900 1830 {}
C {devices/lab_pin.sym} 1900 1830 0 0 {name=l231 sig_type=std_logic lab=outn}
C {driver.sym} 2700 1500 0 0 {name=xdrv_t19}
N 2620 1510 2600 1510 {}
C {devices/lab_pin.sym} 2600 1510 0 0 {name=l232 sig_type=std_logic lab=t19}
N 2620 1530 2600 1530 {}
C {devices/lab_pin.sym} 2600 1530 0 0 {name=l233 sig_type=std_logic lab=vdd}
N 2620 1550 2600 1550 {}
C {devices/lab_pin.sym} 2600 1550 0 0 {name=l234 sig_type=std_logic lab=vss}
N 2780 1510 2800 1510 {}
C {devices/lab_pin.sym} 2800 1510 2 0 {name=l235 sig_type=std_logic lab=sp_t19}
N 2780 1530 2800 1530 {}
C {devices/lab_pin.sym} 2800 1530 2 0 {name=l236 sig_type=std_logic lab=sn_t19}
C {elem_16.sym} 2700 1700 0 0 {name=xel_t19}
N 2620 1710 2600 1710 {}
C {devices/lab_pin.sym} 2600 1710 0 0 {name=l237 sig_type=std_logic lab=vbn}
N 2620 1730 2600 1730 {}
C {devices/lab_pin.sym} 2600 1730 0 0 {name=l238 sig_type=std_logic lab=iref}
N 2620 1750 2600 1750 {}
C {devices/lab_pin.sym} 2600 1750 0 0 {name=l239 sig_type=std_logic lab=sp_t19}
N 2620 1770 2600 1770 {}
C {devices/lab_pin.sym} 2600 1770 0 0 {name=l240 sig_type=std_logic lab=sn_t19}
N 2620 1790 2600 1790 {}
C {devices/lab_pin.sym} 2600 1790 0 0 {name=l241 sig_type=std_logic lab=vss}
N 2620 1810 2600 1810 {}
C {devices/lab_pin.sym} 2600 1810 0 0 {name=l242 sig_type=std_logic lab=outp}
N 2620 1830 2600 1830 {}
C {devices/lab_pin.sym} 2600 1830 0 0 {name=l243 sig_type=std_logic lab=outn}
C {driver.sym} 3400 1500 0 0 {name=xdrv_t20}
N 3320 1510 3300 1510 {}
C {devices/lab_pin.sym} 3300 1510 0 0 {name=l244 sig_type=std_logic lab=t20}
N 3320 1530 3300 1530 {}
C {devices/lab_pin.sym} 3300 1530 0 0 {name=l245 sig_type=std_logic lab=vdd}
N 3320 1550 3300 1550 {}
C {devices/lab_pin.sym} 3300 1550 0 0 {name=l246 sig_type=std_logic lab=vss}
N 3480 1510 3500 1510 {}
C {devices/lab_pin.sym} 3500 1510 2 0 {name=l247 sig_type=std_logic lab=sp_t20}
N 3480 1530 3500 1530 {}
C {devices/lab_pin.sym} 3500 1530 2 0 {name=l248 sig_type=std_logic lab=sn_t20}
C {elem_16.sym} 3400 1700 0 0 {name=xel_t20}
N 3320 1710 3300 1710 {}
C {devices/lab_pin.sym} 3300 1710 0 0 {name=l249 sig_type=std_logic lab=vbn}
N 3320 1730 3300 1730 {}
C {devices/lab_pin.sym} 3300 1730 0 0 {name=l250 sig_type=std_logic lab=iref}
N 3320 1750 3300 1750 {}
C {devices/lab_pin.sym} 3300 1750 0 0 {name=l251 sig_type=std_logic lab=sp_t20}
N 3320 1770 3300 1770 {}
C {devices/lab_pin.sym} 3300 1770 0 0 {name=l252 sig_type=std_logic lab=sn_t20}
N 3320 1790 3300 1790 {}
C {devices/lab_pin.sym} 3300 1790 0 0 {name=l253 sig_type=std_logic lab=vss}
N 3320 1810 3300 1810 {}
C {devices/lab_pin.sym} 3300 1810 0 0 {name=l254 sig_type=std_logic lab=outp}
N 3320 1830 3300 1830 {}
C {devices/lab_pin.sym} 3300 1830 0 0 {name=l255 sig_type=std_logic lab=outn}
C {driver.sym} 4100 1500 0 0 {name=xdrv_t21}
N 4020 1510 4000 1510 {}
C {devices/lab_pin.sym} 4000 1510 0 0 {name=l256 sig_type=std_logic lab=t21}
N 4020 1530 4000 1530 {}
C {devices/lab_pin.sym} 4000 1530 0 0 {name=l257 sig_type=std_logic lab=vdd}
N 4020 1550 4000 1550 {}
C {devices/lab_pin.sym} 4000 1550 0 0 {name=l258 sig_type=std_logic lab=vss}
N 4180 1510 4200 1510 {}
C {devices/lab_pin.sym} 4200 1510 2 0 {name=l259 sig_type=std_logic lab=sp_t21}
N 4180 1530 4200 1530 {}
C {devices/lab_pin.sym} 4200 1530 2 0 {name=l260 sig_type=std_logic lab=sn_t21}
C {elem_16.sym} 4100 1700 0 0 {name=xel_t21}
N 4020 1710 4000 1710 {}
C {devices/lab_pin.sym} 4000 1710 0 0 {name=l261 sig_type=std_logic lab=vbn}
N 4020 1730 4000 1730 {}
C {devices/lab_pin.sym} 4000 1730 0 0 {name=l262 sig_type=std_logic lab=iref}
N 4020 1750 4000 1750 {}
C {devices/lab_pin.sym} 4000 1750 0 0 {name=l263 sig_type=std_logic lab=sp_t21}
N 4020 1770 4000 1770 {}
C {devices/lab_pin.sym} 4000 1770 0 0 {name=l264 sig_type=std_logic lab=sn_t21}
N 4020 1790 4000 1790 {}
C {devices/lab_pin.sym} 4000 1790 0 0 {name=l265 sig_type=std_logic lab=vss}
N 4020 1810 4000 1810 {}
C {devices/lab_pin.sym} 4000 1810 0 0 {name=l266 sig_type=std_logic lab=outp}
N 4020 1830 4000 1830 {}
C {devices/lab_pin.sym} 4000 1830 0 0 {name=l267 sig_type=std_logic lab=outn}
C {driver.sym} 4800 1500 0 0 {name=xdrv_t22}
N 4720 1510 4700 1510 {}
C {devices/lab_pin.sym} 4700 1510 0 0 {name=l268 sig_type=std_logic lab=t22}
N 4720 1530 4700 1530 {}
C {devices/lab_pin.sym} 4700 1530 0 0 {name=l269 sig_type=std_logic lab=vdd}
N 4720 1550 4700 1550 {}
C {devices/lab_pin.sym} 4700 1550 0 0 {name=l270 sig_type=std_logic lab=vss}
N 4880 1510 4900 1510 {}
C {devices/lab_pin.sym} 4900 1510 2 0 {name=l271 sig_type=std_logic lab=sp_t22}
N 4880 1530 4900 1530 {}
C {devices/lab_pin.sym} 4900 1530 2 0 {name=l272 sig_type=std_logic lab=sn_t22}
C {elem_16.sym} 4800 1700 0 0 {name=xel_t22}
N 4720 1710 4700 1710 {}
C {devices/lab_pin.sym} 4700 1710 0 0 {name=l273 sig_type=std_logic lab=vbn}
N 4720 1730 4700 1730 {}
C {devices/lab_pin.sym} 4700 1730 0 0 {name=l274 sig_type=std_logic lab=iref}
N 4720 1750 4700 1750 {}
C {devices/lab_pin.sym} 4700 1750 0 0 {name=l275 sig_type=std_logic lab=sp_t22}
N 4720 1770 4700 1770 {}
C {devices/lab_pin.sym} 4700 1770 0 0 {name=l276 sig_type=std_logic lab=sn_t22}
N 4720 1790 4700 1790 {}
C {devices/lab_pin.sym} 4700 1790 0 0 {name=l277 sig_type=std_logic lab=vss}
N 4720 1810 4700 1810 {}
C {devices/lab_pin.sym} 4700 1810 0 0 {name=l278 sig_type=std_logic lab=outp}
N 4720 1830 4700 1830 {}
C {devices/lab_pin.sym} 4700 1830 0 0 {name=l279 sig_type=std_logic lab=outn}
C {driver.sym} 5500 1500 0 0 {name=xdrv_t23}
N 5420 1510 5400 1510 {}
C {devices/lab_pin.sym} 5400 1510 0 0 {name=l280 sig_type=std_logic lab=t23}
N 5420 1530 5400 1530 {}
C {devices/lab_pin.sym} 5400 1530 0 0 {name=l281 sig_type=std_logic lab=vdd}
N 5420 1550 5400 1550 {}
C {devices/lab_pin.sym} 5400 1550 0 0 {name=l282 sig_type=std_logic lab=vss}
N 5580 1510 5600 1510 {}
C {devices/lab_pin.sym} 5600 1510 2 0 {name=l283 sig_type=std_logic lab=sp_t23}
N 5580 1530 5600 1530 {}
C {devices/lab_pin.sym} 5600 1530 2 0 {name=l284 sig_type=std_logic lab=sn_t23}
C {elem_16.sym} 5500 1700 0 0 {name=xel_t23}
N 5420 1710 5400 1710 {}
C {devices/lab_pin.sym} 5400 1710 0 0 {name=l285 sig_type=std_logic lab=vbn}
N 5420 1730 5400 1730 {}
C {devices/lab_pin.sym} 5400 1730 0 0 {name=l286 sig_type=std_logic lab=iref}
N 5420 1750 5400 1750 {}
C {devices/lab_pin.sym} 5400 1750 0 0 {name=l287 sig_type=std_logic lab=sp_t23}
N 5420 1770 5400 1770 {}
C {devices/lab_pin.sym} 5400 1770 0 0 {name=l288 sig_type=std_logic lab=sn_t23}
N 5420 1790 5400 1790 {}
C {devices/lab_pin.sym} 5400 1790 0 0 {name=l289 sig_type=std_logic lab=vss}
N 5420 1810 5400 1810 {}
C {devices/lab_pin.sym} 5400 1810 0 0 {name=l290 sig_type=std_logic lab=outp}
N 5420 1830 5400 1830 {}
C {devices/lab_pin.sym} 5400 1830 0 0 {name=l291 sig_type=std_logic lab=outn}
C {driver.sym} 600 2100 0 0 {name=xdrv_t24}
N 520 2110 500 2110 {}
C {devices/lab_pin.sym} 500 2110 0 0 {name=l292 sig_type=std_logic lab=t24}
N 520 2130 500 2130 {}
C {devices/lab_pin.sym} 500 2130 0 0 {name=l293 sig_type=std_logic lab=vdd}
N 520 2150 500 2150 {}
C {devices/lab_pin.sym} 500 2150 0 0 {name=l294 sig_type=std_logic lab=vss}
N 680 2110 700 2110 {}
C {devices/lab_pin.sym} 700 2110 2 0 {name=l295 sig_type=std_logic lab=sp_t24}
N 680 2130 700 2130 {}
C {devices/lab_pin.sym} 700 2130 2 0 {name=l296 sig_type=std_logic lab=sn_t24}
C {elem_16.sym} 600 2300 0 0 {name=xel_t24}
N 520 2310 500 2310 {}
C {devices/lab_pin.sym} 500 2310 0 0 {name=l297 sig_type=std_logic lab=vbn}
N 520 2330 500 2330 {}
C {devices/lab_pin.sym} 500 2330 0 0 {name=l298 sig_type=std_logic lab=iref}
N 520 2350 500 2350 {}
C {devices/lab_pin.sym} 500 2350 0 0 {name=l299 sig_type=std_logic lab=sp_t24}
N 520 2370 500 2370 {}
C {devices/lab_pin.sym} 500 2370 0 0 {name=l300 sig_type=std_logic lab=sn_t24}
N 520 2390 500 2390 {}
C {devices/lab_pin.sym} 500 2390 0 0 {name=l301 sig_type=std_logic lab=vss}
N 520 2410 500 2410 {}
C {devices/lab_pin.sym} 500 2410 0 0 {name=l302 sig_type=std_logic lab=outp}
N 520 2430 500 2430 {}
C {devices/lab_pin.sym} 500 2430 0 0 {name=l303 sig_type=std_logic lab=outn}
C {driver.sym} 1300 2100 0 0 {name=xdrv_t25}
N 1220 2110 1200 2110 {}
C {devices/lab_pin.sym} 1200 2110 0 0 {name=l304 sig_type=std_logic lab=t25}
N 1220 2130 1200 2130 {}
C {devices/lab_pin.sym} 1200 2130 0 0 {name=l305 sig_type=std_logic lab=vdd}
N 1220 2150 1200 2150 {}
C {devices/lab_pin.sym} 1200 2150 0 0 {name=l306 sig_type=std_logic lab=vss}
N 1380 2110 1400 2110 {}
C {devices/lab_pin.sym} 1400 2110 2 0 {name=l307 sig_type=std_logic lab=sp_t25}
N 1380 2130 1400 2130 {}
C {devices/lab_pin.sym} 1400 2130 2 0 {name=l308 sig_type=std_logic lab=sn_t25}
C {elem_16.sym} 1300 2300 0 0 {name=xel_t25}
N 1220 2310 1200 2310 {}
C {devices/lab_pin.sym} 1200 2310 0 0 {name=l309 sig_type=std_logic lab=vbn}
N 1220 2330 1200 2330 {}
C {devices/lab_pin.sym} 1200 2330 0 0 {name=l310 sig_type=std_logic lab=iref}
N 1220 2350 1200 2350 {}
C {devices/lab_pin.sym} 1200 2350 0 0 {name=l311 sig_type=std_logic lab=sp_t25}
N 1220 2370 1200 2370 {}
C {devices/lab_pin.sym} 1200 2370 0 0 {name=l312 sig_type=std_logic lab=sn_t25}
N 1220 2390 1200 2390 {}
C {devices/lab_pin.sym} 1200 2390 0 0 {name=l313 sig_type=std_logic lab=vss}
N 1220 2410 1200 2410 {}
C {devices/lab_pin.sym} 1200 2410 0 0 {name=l314 sig_type=std_logic lab=outp}
N 1220 2430 1200 2430 {}
C {devices/lab_pin.sym} 1200 2430 0 0 {name=l315 sig_type=std_logic lab=outn}
C {driver.sym} 2000 2100 0 0 {name=xdrv_t26}
N 1920 2110 1900 2110 {}
C {devices/lab_pin.sym} 1900 2110 0 0 {name=l316 sig_type=std_logic lab=t26}
N 1920 2130 1900 2130 {}
C {devices/lab_pin.sym} 1900 2130 0 0 {name=l317 sig_type=std_logic lab=vdd}
N 1920 2150 1900 2150 {}
C {devices/lab_pin.sym} 1900 2150 0 0 {name=l318 sig_type=std_logic lab=vss}
N 2080 2110 2100 2110 {}
C {devices/lab_pin.sym} 2100 2110 2 0 {name=l319 sig_type=std_logic lab=sp_t26}
N 2080 2130 2100 2130 {}
C {devices/lab_pin.sym} 2100 2130 2 0 {name=l320 sig_type=std_logic lab=sn_t26}
C {elem_16.sym} 2000 2300 0 0 {name=xel_t26}
N 1920 2310 1900 2310 {}
C {devices/lab_pin.sym} 1900 2310 0 0 {name=l321 sig_type=std_logic lab=vbn}
N 1920 2330 1900 2330 {}
C {devices/lab_pin.sym} 1900 2330 0 0 {name=l322 sig_type=std_logic lab=iref}
N 1920 2350 1900 2350 {}
C {devices/lab_pin.sym} 1900 2350 0 0 {name=l323 sig_type=std_logic lab=sp_t26}
N 1920 2370 1900 2370 {}
C {devices/lab_pin.sym} 1900 2370 0 0 {name=l324 sig_type=std_logic lab=sn_t26}
N 1920 2390 1900 2390 {}
C {devices/lab_pin.sym} 1900 2390 0 0 {name=l325 sig_type=std_logic lab=vss}
N 1920 2410 1900 2410 {}
C {devices/lab_pin.sym} 1900 2410 0 0 {name=l326 sig_type=std_logic lab=outp}
N 1920 2430 1900 2430 {}
C {devices/lab_pin.sym} 1900 2430 0 0 {name=l327 sig_type=std_logic lab=outn}
C {driver.sym} 2700 2100 0 0 {name=xdrv_t27}
N 2620 2110 2600 2110 {}
C {devices/lab_pin.sym} 2600 2110 0 0 {name=l328 sig_type=std_logic lab=t27}
N 2620 2130 2600 2130 {}
C {devices/lab_pin.sym} 2600 2130 0 0 {name=l329 sig_type=std_logic lab=vdd}
N 2620 2150 2600 2150 {}
C {devices/lab_pin.sym} 2600 2150 0 0 {name=l330 sig_type=std_logic lab=vss}
N 2780 2110 2800 2110 {}
C {devices/lab_pin.sym} 2800 2110 2 0 {name=l331 sig_type=std_logic lab=sp_t27}
N 2780 2130 2800 2130 {}
C {devices/lab_pin.sym} 2800 2130 2 0 {name=l332 sig_type=std_logic lab=sn_t27}
C {elem_16.sym} 2700 2300 0 0 {name=xel_t27}
N 2620 2310 2600 2310 {}
C {devices/lab_pin.sym} 2600 2310 0 0 {name=l333 sig_type=std_logic lab=vbn}
N 2620 2330 2600 2330 {}
C {devices/lab_pin.sym} 2600 2330 0 0 {name=l334 sig_type=std_logic lab=iref}
N 2620 2350 2600 2350 {}
C {devices/lab_pin.sym} 2600 2350 0 0 {name=l335 sig_type=std_logic lab=sp_t27}
N 2620 2370 2600 2370 {}
C {devices/lab_pin.sym} 2600 2370 0 0 {name=l336 sig_type=std_logic lab=sn_t27}
N 2620 2390 2600 2390 {}
C {devices/lab_pin.sym} 2600 2390 0 0 {name=l337 sig_type=std_logic lab=vss}
N 2620 2410 2600 2410 {}
C {devices/lab_pin.sym} 2600 2410 0 0 {name=l338 sig_type=std_logic lab=outp}
N 2620 2430 2600 2430 {}
C {devices/lab_pin.sym} 2600 2430 0 0 {name=l339 sig_type=std_logic lab=outn}
C {driver.sym} 3400 2100 0 0 {name=xdrv_t28}
N 3320 2110 3300 2110 {}
C {devices/lab_pin.sym} 3300 2110 0 0 {name=l340 sig_type=std_logic lab=t28}
N 3320 2130 3300 2130 {}
C {devices/lab_pin.sym} 3300 2130 0 0 {name=l341 sig_type=std_logic lab=vdd}
N 3320 2150 3300 2150 {}
C {devices/lab_pin.sym} 3300 2150 0 0 {name=l342 sig_type=std_logic lab=vss}
N 3480 2110 3500 2110 {}
C {devices/lab_pin.sym} 3500 2110 2 0 {name=l343 sig_type=std_logic lab=sp_t28}
N 3480 2130 3500 2130 {}
C {devices/lab_pin.sym} 3500 2130 2 0 {name=l344 sig_type=std_logic lab=sn_t28}
C {elem_16.sym} 3400 2300 0 0 {name=xel_t28}
N 3320 2310 3300 2310 {}
C {devices/lab_pin.sym} 3300 2310 0 0 {name=l345 sig_type=std_logic lab=vbn}
N 3320 2330 3300 2330 {}
C {devices/lab_pin.sym} 3300 2330 0 0 {name=l346 sig_type=std_logic lab=iref}
N 3320 2350 3300 2350 {}
C {devices/lab_pin.sym} 3300 2350 0 0 {name=l347 sig_type=std_logic lab=sp_t28}
N 3320 2370 3300 2370 {}
C {devices/lab_pin.sym} 3300 2370 0 0 {name=l348 sig_type=std_logic lab=sn_t28}
N 3320 2390 3300 2390 {}
C {devices/lab_pin.sym} 3300 2390 0 0 {name=l349 sig_type=std_logic lab=vss}
N 3320 2410 3300 2410 {}
C {devices/lab_pin.sym} 3300 2410 0 0 {name=l350 sig_type=std_logic lab=outp}
N 3320 2430 3300 2430 {}
C {devices/lab_pin.sym} 3300 2430 0 0 {name=l351 sig_type=std_logic lab=outn}
C {driver.sym} 4100 2100 0 0 {name=xdrv_t29}
N 4020 2110 4000 2110 {}
C {devices/lab_pin.sym} 4000 2110 0 0 {name=l352 sig_type=std_logic lab=t29}
N 4020 2130 4000 2130 {}
C {devices/lab_pin.sym} 4000 2130 0 0 {name=l353 sig_type=std_logic lab=vdd}
N 4020 2150 4000 2150 {}
C {devices/lab_pin.sym} 4000 2150 0 0 {name=l354 sig_type=std_logic lab=vss}
N 4180 2110 4200 2110 {}
C {devices/lab_pin.sym} 4200 2110 2 0 {name=l355 sig_type=std_logic lab=sp_t29}
N 4180 2130 4200 2130 {}
C {devices/lab_pin.sym} 4200 2130 2 0 {name=l356 sig_type=std_logic lab=sn_t29}
C {elem_16.sym} 4100 2300 0 0 {name=xel_t29}
N 4020 2310 4000 2310 {}
C {devices/lab_pin.sym} 4000 2310 0 0 {name=l357 sig_type=std_logic lab=vbn}
N 4020 2330 4000 2330 {}
C {devices/lab_pin.sym} 4000 2330 0 0 {name=l358 sig_type=std_logic lab=iref}
N 4020 2350 4000 2350 {}
C {devices/lab_pin.sym} 4000 2350 0 0 {name=l359 sig_type=std_logic lab=sp_t29}
N 4020 2370 4000 2370 {}
C {devices/lab_pin.sym} 4000 2370 0 0 {name=l360 sig_type=std_logic lab=sn_t29}
N 4020 2390 4000 2390 {}
C {devices/lab_pin.sym} 4000 2390 0 0 {name=l361 sig_type=std_logic lab=vss}
N 4020 2410 4000 2410 {}
C {devices/lab_pin.sym} 4000 2410 0 0 {name=l362 sig_type=std_logic lab=outp}
N 4020 2430 4000 2430 {}
C {devices/lab_pin.sym} 4000 2430 0 0 {name=l363 sig_type=std_logic lab=outn}
C {driver.sym} 4800 2100 0 0 {name=xdrv_t30}
N 4720 2110 4700 2110 {}
C {devices/lab_pin.sym} 4700 2110 0 0 {name=l364 sig_type=std_logic lab=t30}
N 4720 2130 4700 2130 {}
C {devices/lab_pin.sym} 4700 2130 0 0 {name=l365 sig_type=std_logic lab=vdd}
N 4720 2150 4700 2150 {}
C {devices/lab_pin.sym} 4700 2150 0 0 {name=l366 sig_type=std_logic lab=vss}
N 4880 2110 4900 2110 {}
C {devices/lab_pin.sym} 4900 2110 2 0 {name=l367 sig_type=std_logic lab=sp_t30}
N 4880 2130 4900 2130 {}
C {devices/lab_pin.sym} 4900 2130 2 0 {name=l368 sig_type=std_logic lab=sn_t30}
C {elem_16.sym} 4800 2300 0 0 {name=xel_t30}
N 4720 2310 4700 2310 {}
C {devices/lab_pin.sym} 4700 2310 0 0 {name=l369 sig_type=std_logic lab=vbn}
N 4720 2330 4700 2330 {}
C {devices/lab_pin.sym} 4700 2330 0 0 {name=l370 sig_type=std_logic lab=iref}
N 4720 2350 4700 2350 {}
C {devices/lab_pin.sym} 4700 2350 0 0 {name=l371 sig_type=std_logic lab=sp_t30}
N 4720 2370 4700 2370 {}
C {devices/lab_pin.sym} 4700 2370 0 0 {name=l372 sig_type=std_logic lab=sn_t30}
N 4720 2390 4700 2390 {}
C {devices/lab_pin.sym} 4700 2390 0 0 {name=l373 sig_type=std_logic lab=vss}
N 4720 2410 4700 2410 {}
C {devices/lab_pin.sym} 4700 2410 0 0 {name=l374 sig_type=std_logic lab=outp}
N 4720 2430 4700 2430 {}
C {devices/lab_pin.sym} 4700 2430 0 0 {name=l375 sig_type=std_logic lab=outn}
C {driver.sym} 5500 2100 0 0 {name=xdrv_t31}
N 5420 2110 5400 2110 {}
C {devices/lab_pin.sym} 5400 2110 0 0 {name=l376 sig_type=std_logic lab=t31}
N 5420 2130 5400 2130 {}
C {devices/lab_pin.sym} 5400 2130 0 0 {name=l377 sig_type=std_logic lab=vdd}
N 5420 2150 5400 2150 {}
C {devices/lab_pin.sym} 5400 2150 0 0 {name=l378 sig_type=std_logic lab=vss}
N 5580 2110 5600 2110 {}
C {devices/lab_pin.sym} 5600 2110 2 0 {name=l379 sig_type=std_logic lab=sp_t31}
N 5580 2130 5600 2130 {}
C {devices/lab_pin.sym} 5600 2130 2 0 {name=l380 sig_type=std_logic lab=sn_t31}
C {elem_16.sym} 5500 2300 0 0 {name=xel_t31}
N 5420 2310 5400 2310 {}
C {devices/lab_pin.sym} 5400 2310 0 0 {name=l381 sig_type=std_logic lab=vbn}
N 5420 2330 5400 2330 {}
C {devices/lab_pin.sym} 5400 2330 0 0 {name=l382 sig_type=std_logic lab=iref}
N 5420 2350 5400 2350 {}
C {devices/lab_pin.sym} 5400 2350 0 0 {name=l383 sig_type=std_logic lab=sp_t31}
N 5420 2370 5400 2370 {}
C {devices/lab_pin.sym} 5400 2370 0 0 {name=l384 sig_type=std_logic lab=sn_t31}
N 5420 2390 5400 2390 {}
C {devices/lab_pin.sym} 5400 2390 0 0 {name=l385 sig_type=std_logic lab=vss}
N 5420 2410 5400 2410 {}
C {devices/lab_pin.sym} 5400 2410 0 0 {name=l386 sig_type=std_logic lab=outp}
N 5420 2430 5400 2430 {}
C {devices/lab_pin.sym} 5400 2430 0 0 {name=l387 sig_type=std_logic lab=outn}
C {driver.sym} 600 2700 0 0 {name=xdrv_t32}
N 520 2710 500 2710 {}
C {devices/lab_pin.sym} 500 2710 0 0 {name=l388 sig_type=std_logic lab=t32}
N 520 2730 500 2730 {}
C {devices/lab_pin.sym} 500 2730 0 0 {name=l389 sig_type=std_logic lab=vdd}
N 520 2750 500 2750 {}
C {devices/lab_pin.sym} 500 2750 0 0 {name=l390 sig_type=std_logic lab=vss}
N 680 2710 700 2710 {}
C {devices/lab_pin.sym} 700 2710 2 0 {name=l391 sig_type=std_logic lab=sp_t32}
N 680 2730 700 2730 {}
C {devices/lab_pin.sym} 700 2730 2 0 {name=l392 sig_type=std_logic lab=sn_t32}
C {elem_16.sym} 600 2900 0 0 {name=xel_t32}
N 520 2910 500 2910 {}
C {devices/lab_pin.sym} 500 2910 0 0 {name=l393 sig_type=std_logic lab=vbn}
N 520 2930 500 2930 {}
C {devices/lab_pin.sym} 500 2930 0 0 {name=l394 sig_type=std_logic lab=iref}
N 520 2950 500 2950 {}
C {devices/lab_pin.sym} 500 2950 0 0 {name=l395 sig_type=std_logic lab=sp_t32}
N 520 2970 500 2970 {}
C {devices/lab_pin.sym} 500 2970 0 0 {name=l396 sig_type=std_logic lab=sn_t32}
N 520 2990 500 2990 {}
C {devices/lab_pin.sym} 500 2990 0 0 {name=l397 sig_type=std_logic lab=vss}
N 520 3010 500 3010 {}
C {devices/lab_pin.sym} 500 3010 0 0 {name=l398 sig_type=std_logic lab=outp}
N 520 3030 500 3030 {}
C {devices/lab_pin.sym} 500 3030 0 0 {name=l399 sig_type=std_logic lab=outn}
C {driver.sym} 1300 2700 0 0 {name=xdrv_t33}
N 1220 2710 1200 2710 {}
C {devices/lab_pin.sym} 1200 2710 0 0 {name=l400 sig_type=std_logic lab=t33}
N 1220 2730 1200 2730 {}
C {devices/lab_pin.sym} 1200 2730 0 0 {name=l401 sig_type=std_logic lab=vdd}
N 1220 2750 1200 2750 {}
C {devices/lab_pin.sym} 1200 2750 0 0 {name=l402 sig_type=std_logic lab=vss}
N 1380 2710 1400 2710 {}
C {devices/lab_pin.sym} 1400 2710 2 0 {name=l403 sig_type=std_logic lab=sp_t33}
N 1380 2730 1400 2730 {}
C {devices/lab_pin.sym} 1400 2730 2 0 {name=l404 sig_type=std_logic lab=sn_t33}
C {elem_16.sym} 1300 2900 0 0 {name=xel_t33}
N 1220 2910 1200 2910 {}
C {devices/lab_pin.sym} 1200 2910 0 0 {name=l405 sig_type=std_logic lab=vbn}
N 1220 2930 1200 2930 {}
C {devices/lab_pin.sym} 1200 2930 0 0 {name=l406 sig_type=std_logic lab=iref}
N 1220 2950 1200 2950 {}
C {devices/lab_pin.sym} 1200 2950 0 0 {name=l407 sig_type=std_logic lab=sp_t33}
N 1220 2970 1200 2970 {}
C {devices/lab_pin.sym} 1200 2970 0 0 {name=l408 sig_type=std_logic lab=sn_t33}
N 1220 2990 1200 2990 {}
C {devices/lab_pin.sym} 1200 2990 0 0 {name=l409 sig_type=std_logic lab=vss}
N 1220 3010 1200 3010 {}
C {devices/lab_pin.sym} 1200 3010 0 0 {name=l410 sig_type=std_logic lab=outp}
N 1220 3030 1200 3030 {}
C {devices/lab_pin.sym} 1200 3030 0 0 {name=l411 sig_type=std_logic lab=outn}
C {driver.sym} 2000 2700 0 0 {name=xdrv_t34}
N 1920 2710 1900 2710 {}
C {devices/lab_pin.sym} 1900 2710 0 0 {name=l412 sig_type=std_logic lab=t34}
N 1920 2730 1900 2730 {}
C {devices/lab_pin.sym} 1900 2730 0 0 {name=l413 sig_type=std_logic lab=vdd}
N 1920 2750 1900 2750 {}
C {devices/lab_pin.sym} 1900 2750 0 0 {name=l414 sig_type=std_logic lab=vss}
N 2080 2710 2100 2710 {}
C {devices/lab_pin.sym} 2100 2710 2 0 {name=l415 sig_type=std_logic lab=sp_t34}
N 2080 2730 2100 2730 {}
C {devices/lab_pin.sym} 2100 2730 2 0 {name=l416 sig_type=std_logic lab=sn_t34}
C {elem_16.sym} 2000 2900 0 0 {name=xel_t34}
N 1920 2910 1900 2910 {}
C {devices/lab_pin.sym} 1900 2910 0 0 {name=l417 sig_type=std_logic lab=vbn}
N 1920 2930 1900 2930 {}
C {devices/lab_pin.sym} 1900 2930 0 0 {name=l418 sig_type=std_logic lab=iref}
N 1920 2950 1900 2950 {}
C {devices/lab_pin.sym} 1900 2950 0 0 {name=l419 sig_type=std_logic lab=sp_t34}
N 1920 2970 1900 2970 {}
C {devices/lab_pin.sym} 1900 2970 0 0 {name=l420 sig_type=std_logic lab=sn_t34}
N 1920 2990 1900 2990 {}
C {devices/lab_pin.sym} 1900 2990 0 0 {name=l421 sig_type=std_logic lab=vss}
N 1920 3010 1900 3010 {}
C {devices/lab_pin.sym} 1900 3010 0 0 {name=l422 sig_type=std_logic lab=outp}
N 1920 3030 1900 3030 {}
C {devices/lab_pin.sym} 1900 3030 0 0 {name=l423 sig_type=std_logic lab=outn}
C {driver.sym} 2700 2700 0 0 {name=xdrv_t35}
N 2620 2710 2600 2710 {}
C {devices/lab_pin.sym} 2600 2710 0 0 {name=l424 sig_type=std_logic lab=t35}
N 2620 2730 2600 2730 {}
C {devices/lab_pin.sym} 2600 2730 0 0 {name=l425 sig_type=std_logic lab=vdd}
N 2620 2750 2600 2750 {}
C {devices/lab_pin.sym} 2600 2750 0 0 {name=l426 sig_type=std_logic lab=vss}
N 2780 2710 2800 2710 {}
C {devices/lab_pin.sym} 2800 2710 2 0 {name=l427 sig_type=std_logic lab=sp_t35}
N 2780 2730 2800 2730 {}
C {devices/lab_pin.sym} 2800 2730 2 0 {name=l428 sig_type=std_logic lab=sn_t35}
C {elem_16.sym} 2700 2900 0 0 {name=xel_t35}
N 2620 2910 2600 2910 {}
C {devices/lab_pin.sym} 2600 2910 0 0 {name=l429 sig_type=std_logic lab=vbn}
N 2620 2930 2600 2930 {}
C {devices/lab_pin.sym} 2600 2930 0 0 {name=l430 sig_type=std_logic lab=iref}
N 2620 2950 2600 2950 {}
C {devices/lab_pin.sym} 2600 2950 0 0 {name=l431 sig_type=std_logic lab=sp_t35}
N 2620 2970 2600 2970 {}
C {devices/lab_pin.sym} 2600 2970 0 0 {name=l432 sig_type=std_logic lab=sn_t35}
N 2620 2990 2600 2990 {}
C {devices/lab_pin.sym} 2600 2990 0 0 {name=l433 sig_type=std_logic lab=vss}
N 2620 3010 2600 3010 {}
C {devices/lab_pin.sym} 2600 3010 0 0 {name=l434 sig_type=std_logic lab=outp}
N 2620 3030 2600 3030 {}
C {devices/lab_pin.sym} 2600 3030 0 0 {name=l435 sig_type=std_logic lab=outn}
C {driver.sym} 3400 2700 0 0 {name=xdrv_t36}
N 3320 2710 3300 2710 {}
C {devices/lab_pin.sym} 3300 2710 0 0 {name=l436 sig_type=std_logic lab=t36}
N 3320 2730 3300 2730 {}
C {devices/lab_pin.sym} 3300 2730 0 0 {name=l437 sig_type=std_logic lab=vdd}
N 3320 2750 3300 2750 {}
C {devices/lab_pin.sym} 3300 2750 0 0 {name=l438 sig_type=std_logic lab=vss}
N 3480 2710 3500 2710 {}
C {devices/lab_pin.sym} 3500 2710 2 0 {name=l439 sig_type=std_logic lab=sp_t36}
N 3480 2730 3500 2730 {}
C {devices/lab_pin.sym} 3500 2730 2 0 {name=l440 sig_type=std_logic lab=sn_t36}
C {elem_16.sym} 3400 2900 0 0 {name=xel_t36}
N 3320 2910 3300 2910 {}
C {devices/lab_pin.sym} 3300 2910 0 0 {name=l441 sig_type=std_logic lab=vbn}
N 3320 2930 3300 2930 {}
C {devices/lab_pin.sym} 3300 2930 0 0 {name=l442 sig_type=std_logic lab=iref}
N 3320 2950 3300 2950 {}
C {devices/lab_pin.sym} 3300 2950 0 0 {name=l443 sig_type=std_logic lab=sp_t36}
N 3320 2970 3300 2970 {}
C {devices/lab_pin.sym} 3300 2970 0 0 {name=l444 sig_type=std_logic lab=sn_t36}
N 3320 2990 3300 2990 {}
C {devices/lab_pin.sym} 3300 2990 0 0 {name=l445 sig_type=std_logic lab=vss}
N 3320 3010 3300 3010 {}
C {devices/lab_pin.sym} 3300 3010 0 0 {name=l446 sig_type=std_logic lab=outp}
N 3320 3030 3300 3030 {}
C {devices/lab_pin.sym} 3300 3030 0 0 {name=l447 sig_type=std_logic lab=outn}
C {driver.sym} 4100 2700 0 0 {name=xdrv_t37}
N 4020 2710 4000 2710 {}
C {devices/lab_pin.sym} 4000 2710 0 0 {name=l448 sig_type=std_logic lab=t37}
N 4020 2730 4000 2730 {}
C {devices/lab_pin.sym} 4000 2730 0 0 {name=l449 sig_type=std_logic lab=vdd}
N 4020 2750 4000 2750 {}
C {devices/lab_pin.sym} 4000 2750 0 0 {name=l450 sig_type=std_logic lab=vss}
N 4180 2710 4200 2710 {}
C {devices/lab_pin.sym} 4200 2710 2 0 {name=l451 sig_type=std_logic lab=sp_t37}
N 4180 2730 4200 2730 {}
C {devices/lab_pin.sym} 4200 2730 2 0 {name=l452 sig_type=std_logic lab=sn_t37}
C {elem_16.sym} 4100 2900 0 0 {name=xel_t37}
N 4020 2910 4000 2910 {}
C {devices/lab_pin.sym} 4000 2910 0 0 {name=l453 sig_type=std_logic lab=vbn}
N 4020 2930 4000 2930 {}
C {devices/lab_pin.sym} 4000 2930 0 0 {name=l454 sig_type=std_logic lab=iref}
N 4020 2950 4000 2950 {}
C {devices/lab_pin.sym} 4000 2950 0 0 {name=l455 sig_type=std_logic lab=sp_t37}
N 4020 2970 4000 2970 {}
C {devices/lab_pin.sym} 4000 2970 0 0 {name=l456 sig_type=std_logic lab=sn_t37}
N 4020 2990 4000 2990 {}
C {devices/lab_pin.sym} 4000 2990 0 0 {name=l457 sig_type=std_logic lab=vss}
N 4020 3010 4000 3010 {}
C {devices/lab_pin.sym} 4000 3010 0 0 {name=l458 sig_type=std_logic lab=outp}
N 4020 3030 4000 3030 {}
C {devices/lab_pin.sym} 4000 3030 0 0 {name=l459 sig_type=std_logic lab=outn}
C {driver.sym} 4800 2700 0 0 {name=xdrv_t38}
N 4720 2710 4700 2710 {}
C {devices/lab_pin.sym} 4700 2710 0 0 {name=l460 sig_type=std_logic lab=t38}
N 4720 2730 4700 2730 {}
C {devices/lab_pin.sym} 4700 2730 0 0 {name=l461 sig_type=std_logic lab=vdd}
N 4720 2750 4700 2750 {}
C {devices/lab_pin.sym} 4700 2750 0 0 {name=l462 sig_type=std_logic lab=vss}
N 4880 2710 4900 2710 {}
C {devices/lab_pin.sym} 4900 2710 2 0 {name=l463 sig_type=std_logic lab=sp_t38}
N 4880 2730 4900 2730 {}
C {devices/lab_pin.sym} 4900 2730 2 0 {name=l464 sig_type=std_logic lab=sn_t38}
C {elem_16.sym} 4800 2900 0 0 {name=xel_t38}
N 4720 2910 4700 2910 {}
C {devices/lab_pin.sym} 4700 2910 0 0 {name=l465 sig_type=std_logic lab=vbn}
N 4720 2930 4700 2930 {}
C {devices/lab_pin.sym} 4700 2930 0 0 {name=l466 sig_type=std_logic lab=iref}
N 4720 2950 4700 2950 {}
C {devices/lab_pin.sym} 4700 2950 0 0 {name=l467 sig_type=std_logic lab=sp_t38}
N 4720 2970 4700 2970 {}
C {devices/lab_pin.sym} 4700 2970 0 0 {name=l468 sig_type=std_logic lab=sn_t38}
N 4720 2990 4700 2990 {}
C {devices/lab_pin.sym} 4700 2990 0 0 {name=l469 sig_type=std_logic lab=vss}
N 4720 3010 4700 3010 {}
C {devices/lab_pin.sym} 4700 3010 0 0 {name=l470 sig_type=std_logic lab=outp}
N 4720 3030 4700 3030 {}
C {devices/lab_pin.sym} 4700 3030 0 0 {name=l471 sig_type=std_logic lab=outn}
C {driver.sym} 5500 2700 0 0 {name=xdrv_t39}
N 5420 2710 5400 2710 {}
C {devices/lab_pin.sym} 5400 2710 0 0 {name=l472 sig_type=std_logic lab=t39}
N 5420 2730 5400 2730 {}
C {devices/lab_pin.sym} 5400 2730 0 0 {name=l473 sig_type=std_logic lab=vdd}
N 5420 2750 5400 2750 {}
C {devices/lab_pin.sym} 5400 2750 0 0 {name=l474 sig_type=std_logic lab=vss}
N 5580 2710 5600 2710 {}
C {devices/lab_pin.sym} 5600 2710 2 0 {name=l475 sig_type=std_logic lab=sp_t39}
N 5580 2730 5600 2730 {}
C {devices/lab_pin.sym} 5600 2730 2 0 {name=l476 sig_type=std_logic lab=sn_t39}
C {elem_16.sym} 5500 2900 0 0 {name=xel_t39}
N 5420 2910 5400 2910 {}
C {devices/lab_pin.sym} 5400 2910 0 0 {name=l477 sig_type=std_logic lab=vbn}
N 5420 2930 5400 2930 {}
C {devices/lab_pin.sym} 5400 2930 0 0 {name=l478 sig_type=std_logic lab=iref}
N 5420 2950 5400 2950 {}
C {devices/lab_pin.sym} 5400 2950 0 0 {name=l479 sig_type=std_logic lab=sp_t39}
N 5420 2970 5400 2970 {}
C {devices/lab_pin.sym} 5400 2970 0 0 {name=l480 sig_type=std_logic lab=sn_t39}
N 5420 2990 5400 2990 {}
C {devices/lab_pin.sym} 5400 2990 0 0 {name=l481 sig_type=std_logic lab=vss}
N 5420 3010 5400 3010 {}
C {devices/lab_pin.sym} 5400 3010 0 0 {name=l482 sig_type=std_logic lab=outp}
N 5420 3030 5400 3030 {}
C {devices/lab_pin.sym} 5400 3030 0 0 {name=l483 sig_type=std_logic lab=outn}
C {driver.sym} 600 3300 0 0 {name=xdrv_t40}
N 520 3310 500 3310 {}
C {devices/lab_pin.sym} 500 3310 0 0 {name=l484 sig_type=std_logic lab=t40}
N 520 3330 500 3330 {}
C {devices/lab_pin.sym} 500 3330 0 0 {name=l485 sig_type=std_logic lab=vdd}
N 520 3350 500 3350 {}
C {devices/lab_pin.sym} 500 3350 0 0 {name=l486 sig_type=std_logic lab=vss}
N 680 3310 700 3310 {}
C {devices/lab_pin.sym} 700 3310 2 0 {name=l487 sig_type=std_logic lab=sp_t40}
N 680 3330 700 3330 {}
C {devices/lab_pin.sym} 700 3330 2 0 {name=l488 sig_type=std_logic lab=sn_t40}
C {elem_16.sym} 600 3500 0 0 {name=xel_t40}
N 520 3510 500 3510 {}
C {devices/lab_pin.sym} 500 3510 0 0 {name=l489 sig_type=std_logic lab=vbn}
N 520 3530 500 3530 {}
C {devices/lab_pin.sym} 500 3530 0 0 {name=l490 sig_type=std_logic lab=iref}
N 520 3550 500 3550 {}
C {devices/lab_pin.sym} 500 3550 0 0 {name=l491 sig_type=std_logic lab=sp_t40}
N 520 3570 500 3570 {}
C {devices/lab_pin.sym} 500 3570 0 0 {name=l492 sig_type=std_logic lab=sn_t40}
N 520 3590 500 3590 {}
C {devices/lab_pin.sym} 500 3590 0 0 {name=l493 sig_type=std_logic lab=vss}
N 520 3610 500 3610 {}
C {devices/lab_pin.sym} 500 3610 0 0 {name=l494 sig_type=std_logic lab=outp}
N 520 3630 500 3630 {}
C {devices/lab_pin.sym} 500 3630 0 0 {name=l495 sig_type=std_logic lab=outn}
C {driver.sym} 1300 3300 0 0 {name=xdrv_t41}
N 1220 3310 1200 3310 {}
C {devices/lab_pin.sym} 1200 3310 0 0 {name=l496 sig_type=std_logic lab=t41}
N 1220 3330 1200 3330 {}
C {devices/lab_pin.sym} 1200 3330 0 0 {name=l497 sig_type=std_logic lab=vdd}
N 1220 3350 1200 3350 {}
C {devices/lab_pin.sym} 1200 3350 0 0 {name=l498 sig_type=std_logic lab=vss}
N 1380 3310 1400 3310 {}
C {devices/lab_pin.sym} 1400 3310 2 0 {name=l499 sig_type=std_logic lab=sp_t41}
N 1380 3330 1400 3330 {}
C {devices/lab_pin.sym} 1400 3330 2 0 {name=l500 sig_type=std_logic lab=sn_t41}
C {elem_16.sym} 1300 3500 0 0 {name=xel_t41}
N 1220 3510 1200 3510 {}
C {devices/lab_pin.sym} 1200 3510 0 0 {name=l501 sig_type=std_logic lab=vbn}
N 1220 3530 1200 3530 {}
C {devices/lab_pin.sym} 1200 3530 0 0 {name=l502 sig_type=std_logic lab=iref}
N 1220 3550 1200 3550 {}
C {devices/lab_pin.sym} 1200 3550 0 0 {name=l503 sig_type=std_logic lab=sp_t41}
N 1220 3570 1200 3570 {}
C {devices/lab_pin.sym} 1200 3570 0 0 {name=l504 sig_type=std_logic lab=sn_t41}
N 1220 3590 1200 3590 {}
C {devices/lab_pin.sym} 1200 3590 0 0 {name=l505 sig_type=std_logic lab=vss}
N 1220 3610 1200 3610 {}
C {devices/lab_pin.sym} 1200 3610 0 0 {name=l506 sig_type=std_logic lab=outp}
N 1220 3630 1200 3630 {}
C {devices/lab_pin.sym} 1200 3630 0 0 {name=l507 sig_type=std_logic lab=outn}
C {driver.sym} 2000 3300 0 0 {name=xdrv_t42}
N 1920 3310 1900 3310 {}
C {devices/lab_pin.sym} 1900 3310 0 0 {name=l508 sig_type=std_logic lab=t42}
N 1920 3330 1900 3330 {}
C {devices/lab_pin.sym} 1900 3330 0 0 {name=l509 sig_type=std_logic lab=vdd}
N 1920 3350 1900 3350 {}
C {devices/lab_pin.sym} 1900 3350 0 0 {name=l510 sig_type=std_logic lab=vss}
N 2080 3310 2100 3310 {}
C {devices/lab_pin.sym} 2100 3310 2 0 {name=l511 sig_type=std_logic lab=sp_t42}
N 2080 3330 2100 3330 {}
C {devices/lab_pin.sym} 2100 3330 2 0 {name=l512 sig_type=std_logic lab=sn_t42}
C {elem_16.sym} 2000 3500 0 0 {name=xel_t42}
N 1920 3510 1900 3510 {}
C {devices/lab_pin.sym} 1900 3510 0 0 {name=l513 sig_type=std_logic lab=vbn}
N 1920 3530 1900 3530 {}
C {devices/lab_pin.sym} 1900 3530 0 0 {name=l514 sig_type=std_logic lab=iref}
N 1920 3550 1900 3550 {}
C {devices/lab_pin.sym} 1900 3550 0 0 {name=l515 sig_type=std_logic lab=sp_t42}
N 1920 3570 1900 3570 {}
C {devices/lab_pin.sym} 1900 3570 0 0 {name=l516 sig_type=std_logic lab=sn_t42}
N 1920 3590 1900 3590 {}
C {devices/lab_pin.sym} 1900 3590 0 0 {name=l517 sig_type=std_logic lab=vss}
N 1920 3610 1900 3610 {}
C {devices/lab_pin.sym} 1900 3610 0 0 {name=l518 sig_type=std_logic lab=outp}
N 1920 3630 1900 3630 {}
C {devices/lab_pin.sym} 1900 3630 0 0 {name=l519 sig_type=std_logic lab=outn}
C {driver.sym} 2700 3300 0 0 {name=xdrv_t43}
N 2620 3310 2600 3310 {}
C {devices/lab_pin.sym} 2600 3310 0 0 {name=l520 sig_type=std_logic lab=t43}
N 2620 3330 2600 3330 {}
C {devices/lab_pin.sym} 2600 3330 0 0 {name=l521 sig_type=std_logic lab=vdd}
N 2620 3350 2600 3350 {}
C {devices/lab_pin.sym} 2600 3350 0 0 {name=l522 sig_type=std_logic lab=vss}
N 2780 3310 2800 3310 {}
C {devices/lab_pin.sym} 2800 3310 2 0 {name=l523 sig_type=std_logic lab=sp_t43}
N 2780 3330 2800 3330 {}
C {devices/lab_pin.sym} 2800 3330 2 0 {name=l524 sig_type=std_logic lab=sn_t43}
C {elem_16.sym} 2700 3500 0 0 {name=xel_t43}
N 2620 3510 2600 3510 {}
C {devices/lab_pin.sym} 2600 3510 0 0 {name=l525 sig_type=std_logic lab=vbn}
N 2620 3530 2600 3530 {}
C {devices/lab_pin.sym} 2600 3530 0 0 {name=l526 sig_type=std_logic lab=iref}
N 2620 3550 2600 3550 {}
C {devices/lab_pin.sym} 2600 3550 0 0 {name=l527 sig_type=std_logic lab=sp_t43}
N 2620 3570 2600 3570 {}
C {devices/lab_pin.sym} 2600 3570 0 0 {name=l528 sig_type=std_logic lab=sn_t43}
N 2620 3590 2600 3590 {}
C {devices/lab_pin.sym} 2600 3590 0 0 {name=l529 sig_type=std_logic lab=vss}
N 2620 3610 2600 3610 {}
C {devices/lab_pin.sym} 2600 3610 0 0 {name=l530 sig_type=std_logic lab=outp}
N 2620 3630 2600 3630 {}
C {devices/lab_pin.sym} 2600 3630 0 0 {name=l531 sig_type=std_logic lab=outn}
C {driver.sym} 3400 3300 0 0 {name=xdrv_t44}
N 3320 3310 3300 3310 {}
C {devices/lab_pin.sym} 3300 3310 0 0 {name=l532 sig_type=std_logic lab=t44}
N 3320 3330 3300 3330 {}
C {devices/lab_pin.sym} 3300 3330 0 0 {name=l533 sig_type=std_logic lab=vdd}
N 3320 3350 3300 3350 {}
C {devices/lab_pin.sym} 3300 3350 0 0 {name=l534 sig_type=std_logic lab=vss}
N 3480 3310 3500 3310 {}
C {devices/lab_pin.sym} 3500 3310 2 0 {name=l535 sig_type=std_logic lab=sp_t44}
N 3480 3330 3500 3330 {}
C {devices/lab_pin.sym} 3500 3330 2 0 {name=l536 sig_type=std_logic lab=sn_t44}
C {elem_16.sym} 3400 3500 0 0 {name=xel_t44}
N 3320 3510 3300 3510 {}
C {devices/lab_pin.sym} 3300 3510 0 0 {name=l537 sig_type=std_logic lab=vbn}
N 3320 3530 3300 3530 {}
C {devices/lab_pin.sym} 3300 3530 0 0 {name=l538 sig_type=std_logic lab=iref}
N 3320 3550 3300 3550 {}
C {devices/lab_pin.sym} 3300 3550 0 0 {name=l539 sig_type=std_logic lab=sp_t44}
N 3320 3570 3300 3570 {}
C {devices/lab_pin.sym} 3300 3570 0 0 {name=l540 sig_type=std_logic lab=sn_t44}
N 3320 3590 3300 3590 {}
C {devices/lab_pin.sym} 3300 3590 0 0 {name=l541 sig_type=std_logic lab=vss}
N 3320 3610 3300 3610 {}
C {devices/lab_pin.sym} 3300 3610 0 0 {name=l542 sig_type=std_logic lab=outp}
N 3320 3630 3300 3630 {}
C {devices/lab_pin.sym} 3300 3630 0 0 {name=l543 sig_type=std_logic lab=outn}
C {driver.sym} 4100 3300 0 0 {name=xdrv_t45}
N 4020 3310 4000 3310 {}
C {devices/lab_pin.sym} 4000 3310 0 0 {name=l544 sig_type=std_logic lab=t45}
N 4020 3330 4000 3330 {}
C {devices/lab_pin.sym} 4000 3330 0 0 {name=l545 sig_type=std_logic lab=vdd}
N 4020 3350 4000 3350 {}
C {devices/lab_pin.sym} 4000 3350 0 0 {name=l546 sig_type=std_logic lab=vss}
N 4180 3310 4200 3310 {}
C {devices/lab_pin.sym} 4200 3310 2 0 {name=l547 sig_type=std_logic lab=sp_t45}
N 4180 3330 4200 3330 {}
C {devices/lab_pin.sym} 4200 3330 2 0 {name=l548 sig_type=std_logic lab=sn_t45}
C {elem_16.sym} 4100 3500 0 0 {name=xel_t45}
N 4020 3510 4000 3510 {}
C {devices/lab_pin.sym} 4000 3510 0 0 {name=l549 sig_type=std_logic lab=vbn}
N 4020 3530 4000 3530 {}
C {devices/lab_pin.sym} 4000 3530 0 0 {name=l550 sig_type=std_logic lab=iref}
N 4020 3550 4000 3550 {}
C {devices/lab_pin.sym} 4000 3550 0 0 {name=l551 sig_type=std_logic lab=sp_t45}
N 4020 3570 4000 3570 {}
C {devices/lab_pin.sym} 4000 3570 0 0 {name=l552 sig_type=std_logic lab=sn_t45}
N 4020 3590 4000 3590 {}
C {devices/lab_pin.sym} 4000 3590 0 0 {name=l553 sig_type=std_logic lab=vss}
N 4020 3610 4000 3610 {}
C {devices/lab_pin.sym} 4000 3610 0 0 {name=l554 sig_type=std_logic lab=outp}
N 4020 3630 4000 3630 {}
C {devices/lab_pin.sym} 4000 3630 0 0 {name=l555 sig_type=std_logic lab=outn}
C {driver.sym} 4800 3300 0 0 {name=xdrv_t46}
N 4720 3310 4700 3310 {}
C {devices/lab_pin.sym} 4700 3310 0 0 {name=l556 sig_type=std_logic lab=t46}
N 4720 3330 4700 3330 {}
C {devices/lab_pin.sym} 4700 3330 0 0 {name=l557 sig_type=std_logic lab=vdd}
N 4720 3350 4700 3350 {}
C {devices/lab_pin.sym} 4700 3350 0 0 {name=l558 sig_type=std_logic lab=vss}
N 4880 3310 4900 3310 {}
C {devices/lab_pin.sym} 4900 3310 2 0 {name=l559 sig_type=std_logic lab=sp_t46}
N 4880 3330 4900 3330 {}
C {devices/lab_pin.sym} 4900 3330 2 0 {name=l560 sig_type=std_logic lab=sn_t46}
C {elem_16.sym} 4800 3500 0 0 {name=xel_t46}
N 4720 3510 4700 3510 {}
C {devices/lab_pin.sym} 4700 3510 0 0 {name=l561 sig_type=std_logic lab=vbn}
N 4720 3530 4700 3530 {}
C {devices/lab_pin.sym} 4700 3530 0 0 {name=l562 sig_type=std_logic lab=iref}
N 4720 3550 4700 3550 {}
C {devices/lab_pin.sym} 4700 3550 0 0 {name=l563 sig_type=std_logic lab=sp_t46}
N 4720 3570 4700 3570 {}
C {devices/lab_pin.sym} 4700 3570 0 0 {name=l564 sig_type=std_logic lab=sn_t46}
N 4720 3590 4700 3590 {}
C {devices/lab_pin.sym} 4700 3590 0 0 {name=l565 sig_type=std_logic lab=vss}
N 4720 3610 4700 3610 {}
C {devices/lab_pin.sym} 4700 3610 0 0 {name=l566 sig_type=std_logic lab=outp}
N 4720 3630 4700 3630 {}
C {devices/lab_pin.sym} 4700 3630 0 0 {name=l567 sig_type=std_logic lab=outn}
C {driver.sym} 5500 3300 0 0 {name=xdrv_t47}
N 5420 3310 5400 3310 {}
C {devices/lab_pin.sym} 5400 3310 0 0 {name=l568 sig_type=std_logic lab=t47}
N 5420 3330 5400 3330 {}
C {devices/lab_pin.sym} 5400 3330 0 0 {name=l569 sig_type=std_logic lab=vdd}
N 5420 3350 5400 3350 {}
C {devices/lab_pin.sym} 5400 3350 0 0 {name=l570 sig_type=std_logic lab=vss}
N 5580 3310 5600 3310 {}
C {devices/lab_pin.sym} 5600 3310 2 0 {name=l571 sig_type=std_logic lab=sp_t47}
N 5580 3330 5600 3330 {}
C {devices/lab_pin.sym} 5600 3330 2 0 {name=l572 sig_type=std_logic lab=sn_t47}
C {elem_16.sym} 5500 3500 0 0 {name=xel_t47}
N 5420 3510 5400 3510 {}
C {devices/lab_pin.sym} 5400 3510 0 0 {name=l573 sig_type=std_logic lab=vbn}
N 5420 3530 5400 3530 {}
C {devices/lab_pin.sym} 5400 3530 0 0 {name=l574 sig_type=std_logic lab=iref}
N 5420 3550 5400 3550 {}
C {devices/lab_pin.sym} 5400 3550 0 0 {name=l575 sig_type=std_logic lab=sp_t47}
N 5420 3570 5400 3570 {}
C {devices/lab_pin.sym} 5400 3570 0 0 {name=l576 sig_type=std_logic lab=sn_t47}
N 5420 3590 5400 3590 {}
C {devices/lab_pin.sym} 5400 3590 0 0 {name=l577 sig_type=std_logic lab=vss}
N 5420 3610 5400 3610 {}
C {devices/lab_pin.sym} 5400 3610 0 0 {name=l578 sig_type=std_logic lab=outp}
N 5420 3630 5400 3630 {}
C {devices/lab_pin.sym} 5400 3630 0 0 {name=l579 sig_type=std_logic lab=outn}
C {driver.sym} 600 3900 0 0 {name=xdrv_t48}
N 520 3910 500 3910 {}
C {devices/lab_pin.sym} 500 3910 0 0 {name=l580 sig_type=std_logic lab=t48}
N 520 3930 500 3930 {}
C {devices/lab_pin.sym} 500 3930 0 0 {name=l581 sig_type=std_logic lab=vdd}
N 520 3950 500 3950 {}
C {devices/lab_pin.sym} 500 3950 0 0 {name=l582 sig_type=std_logic lab=vss}
N 680 3910 700 3910 {}
C {devices/lab_pin.sym} 700 3910 2 0 {name=l583 sig_type=std_logic lab=sp_t48}
N 680 3930 700 3930 {}
C {devices/lab_pin.sym} 700 3930 2 0 {name=l584 sig_type=std_logic lab=sn_t48}
C {elem_16.sym} 600 4100 0 0 {name=xel_t48}
N 520 4110 500 4110 {}
C {devices/lab_pin.sym} 500 4110 0 0 {name=l585 sig_type=std_logic lab=vbn}
N 520 4130 500 4130 {}
C {devices/lab_pin.sym} 500 4130 0 0 {name=l586 sig_type=std_logic lab=iref}
N 520 4150 500 4150 {}
C {devices/lab_pin.sym} 500 4150 0 0 {name=l587 sig_type=std_logic lab=sp_t48}
N 520 4170 500 4170 {}
C {devices/lab_pin.sym} 500 4170 0 0 {name=l588 sig_type=std_logic lab=sn_t48}
N 520 4190 500 4190 {}
C {devices/lab_pin.sym} 500 4190 0 0 {name=l589 sig_type=std_logic lab=vss}
N 520 4210 500 4210 {}
C {devices/lab_pin.sym} 500 4210 0 0 {name=l590 sig_type=std_logic lab=outp}
N 520 4230 500 4230 {}
C {devices/lab_pin.sym} 500 4230 0 0 {name=l591 sig_type=std_logic lab=outn}
C {driver.sym} 1300 3900 0 0 {name=xdrv_t49}
N 1220 3910 1200 3910 {}
C {devices/lab_pin.sym} 1200 3910 0 0 {name=l592 sig_type=std_logic lab=t49}
N 1220 3930 1200 3930 {}
C {devices/lab_pin.sym} 1200 3930 0 0 {name=l593 sig_type=std_logic lab=vdd}
N 1220 3950 1200 3950 {}
C {devices/lab_pin.sym} 1200 3950 0 0 {name=l594 sig_type=std_logic lab=vss}
N 1380 3910 1400 3910 {}
C {devices/lab_pin.sym} 1400 3910 2 0 {name=l595 sig_type=std_logic lab=sp_t49}
N 1380 3930 1400 3930 {}
C {devices/lab_pin.sym} 1400 3930 2 0 {name=l596 sig_type=std_logic lab=sn_t49}
C {elem_16.sym} 1300 4100 0 0 {name=xel_t49}
N 1220 4110 1200 4110 {}
C {devices/lab_pin.sym} 1200 4110 0 0 {name=l597 sig_type=std_logic lab=vbn}
N 1220 4130 1200 4130 {}
C {devices/lab_pin.sym} 1200 4130 0 0 {name=l598 sig_type=std_logic lab=iref}
N 1220 4150 1200 4150 {}
C {devices/lab_pin.sym} 1200 4150 0 0 {name=l599 sig_type=std_logic lab=sp_t49}
N 1220 4170 1200 4170 {}
C {devices/lab_pin.sym} 1200 4170 0 0 {name=l600 sig_type=std_logic lab=sn_t49}
N 1220 4190 1200 4190 {}
C {devices/lab_pin.sym} 1200 4190 0 0 {name=l601 sig_type=std_logic lab=vss}
N 1220 4210 1200 4210 {}
C {devices/lab_pin.sym} 1200 4210 0 0 {name=l602 sig_type=std_logic lab=outp}
N 1220 4230 1200 4230 {}
C {devices/lab_pin.sym} 1200 4230 0 0 {name=l603 sig_type=std_logic lab=outn}
C {driver.sym} 2000 3900 0 0 {name=xdrv_t50}
N 1920 3910 1900 3910 {}
C {devices/lab_pin.sym} 1900 3910 0 0 {name=l604 sig_type=std_logic lab=t50}
N 1920 3930 1900 3930 {}
C {devices/lab_pin.sym} 1900 3930 0 0 {name=l605 sig_type=std_logic lab=vdd}
N 1920 3950 1900 3950 {}
C {devices/lab_pin.sym} 1900 3950 0 0 {name=l606 sig_type=std_logic lab=vss}
N 2080 3910 2100 3910 {}
C {devices/lab_pin.sym} 2100 3910 2 0 {name=l607 sig_type=std_logic lab=sp_t50}
N 2080 3930 2100 3930 {}
C {devices/lab_pin.sym} 2100 3930 2 0 {name=l608 sig_type=std_logic lab=sn_t50}
C {elem_16.sym} 2000 4100 0 0 {name=xel_t50}
N 1920 4110 1900 4110 {}
C {devices/lab_pin.sym} 1900 4110 0 0 {name=l609 sig_type=std_logic lab=vbn}
N 1920 4130 1900 4130 {}
C {devices/lab_pin.sym} 1900 4130 0 0 {name=l610 sig_type=std_logic lab=iref}
N 1920 4150 1900 4150 {}
C {devices/lab_pin.sym} 1900 4150 0 0 {name=l611 sig_type=std_logic lab=sp_t50}
N 1920 4170 1900 4170 {}
C {devices/lab_pin.sym} 1900 4170 0 0 {name=l612 sig_type=std_logic lab=sn_t50}
N 1920 4190 1900 4190 {}
C {devices/lab_pin.sym} 1900 4190 0 0 {name=l613 sig_type=std_logic lab=vss}
N 1920 4210 1900 4210 {}
C {devices/lab_pin.sym} 1900 4210 0 0 {name=l614 sig_type=std_logic lab=outp}
N 1920 4230 1900 4230 {}
C {devices/lab_pin.sym} 1900 4230 0 0 {name=l615 sig_type=std_logic lab=outn}
C {driver.sym} 2700 3900 0 0 {name=xdrv_t51}
N 2620 3910 2600 3910 {}
C {devices/lab_pin.sym} 2600 3910 0 0 {name=l616 sig_type=std_logic lab=t51}
N 2620 3930 2600 3930 {}
C {devices/lab_pin.sym} 2600 3930 0 0 {name=l617 sig_type=std_logic lab=vdd}
N 2620 3950 2600 3950 {}
C {devices/lab_pin.sym} 2600 3950 0 0 {name=l618 sig_type=std_logic lab=vss}
N 2780 3910 2800 3910 {}
C {devices/lab_pin.sym} 2800 3910 2 0 {name=l619 sig_type=std_logic lab=sp_t51}
N 2780 3930 2800 3930 {}
C {devices/lab_pin.sym} 2800 3930 2 0 {name=l620 sig_type=std_logic lab=sn_t51}
C {elem_16.sym} 2700 4100 0 0 {name=xel_t51}
N 2620 4110 2600 4110 {}
C {devices/lab_pin.sym} 2600 4110 0 0 {name=l621 sig_type=std_logic lab=vbn}
N 2620 4130 2600 4130 {}
C {devices/lab_pin.sym} 2600 4130 0 0 {name=l622 sig_type=std_logic lab=iref}
N 2620 4150 2600 4150 {}
C {devices/lab_pin.sym} 2600 4150 0 0 {name=l623 sig_type=std_logic lab=sp_t51}
N 2620 4170 2600 4170 {}
C {devices/lab_pin.sym} 2600 4170 0 0 {name=l624 sig_type=std_logic lab=sn_t51}
N 2620 4190 2600 4190 {}
C {devices/lab_pin.sym} 2600 4190 0 0 {name=l625 sig_type=std_logic lab=vss}
N 2620 4210 2600 4210 {}
C {devices/lab_pin.sym} 2600 4210 0 0 {name=l626 sig_type=std_logic lab=outp}
N 2620 4230 2600 4230 {}
C {devices/lab_pin.sym} 2600 4230 0 0 {name=l627 sig_type=std_logic lab=outn}
C {driver.sym} 3400 3900 0 0 {name=xdrv_t52}
N 3320 3910 3300 3910 {}
C {devices/lab_pin.sym} 3300 3910 0 0 {name=l628 sig_type=std_logic lab=t52}
N 3320 3930 3300 3930 {}
C {devices/lab_pin.sym} 3300 3930 0 0 {name=l629 sig_type=std_logic lab=vdd}
N 3320 3950 3300 3950 {}
C {devices/lab_pin.sym} 3300 3950 0 0 {name=l630 sig_type=std_logic lab=vss}
N 3480 3910 3500 3910 {}
C {devices/lab_pin.sym} 3500 3910 2 0 {name=l631 sig_type=std_logic lab=sp_t52}
N 3480 3930 3500 3930 {}
C {devices/lab_pin.sym} 3500 3930 2 0 {name=l632 sig_type=std_logic lab=sn_t52}
C {elem_16.sym} 3400 4100 0 0 {name=xel_t52}
N 3320 4110 3300 4110 {}
C {devices/lab_pin.sym} 3300 4110 0 0 {name=l633 sig_type=std_logic lab=vbn}
N 3320 4130 3300 4130 {}
C {devices/lab_pin.sym} 3300 4130 0 0 {name=l634 sig_type=std_logic lab=iref}
N 3320 4150 3300 4150 {}
C {devices/lab_pin.sym} 3300 4150 0 0 {name=l635 sig_type=std_logic lab=sp_t52}
N 3320 4170 3300 4170 {}
C {devices/lab_pin.sym} 3300 4170 0 0 {name=l636 sig_type=std_logic lab=sn_t52}
N 3320 4190 3300 4190 {}
C {devices/lab_pin.sym} 3300 4190 0 0 {name=l637 sig_type=std_logic lab=vss}
N 3320 4210 3300 4210 {}
C {devices/lab_pin.sym} 3300 4210 0 0 {name=l638 sig_type=std_logic lab=outp}
N 3320 4230 3300 4230 {}
C {devices/lab_pin.sym} 3300 4230 0 0 {name=l639 sig_type=std_logic lab=outn}
C {driver.sym} 4100 3900 0 0 {name=xdrv_t53}
N 4020 3910 4000 3910 {}
C {devices/lab_pin.sym} 4000 3910 0 0 {name=l640 sig_type=std_logic lab=t53}
N 4020 3930 4000 3930 {}
C {devices/lab_pin.sym} 4000 3930 0 0 {name=l641 sig_type=std_logic lab=vdd}
N 4020 3950 4000 3950 {}
C {devices/lab_pin.sym} 4000 3950 0 0 {name=l642 sig_type=std_logic lab=vss}
N 4180 3910 4200 3910 {}
C {devices/lab_pin.sym} 4200 3910 2 0 {name=l643 sig_type=std_logic lab=sp_t53}
N 4180 3930 4200 3930 {}
C {devices/lab_pin.sym} 4200 3930 2 0 {name=l644 sig_type=std_logic lab=sn_t53}
C {elem_16.sym} 4100 4100 0 0 {name=xel_t53}
N 4020 4110 4000 4110 {}
C {devices/lab_pin.sym} 4000 4110 0 0 {name=l645 sig_type=std_logic lab=vbn}
N 4020 4130 4000 4130 {}
C {devices/lab_pin.sym} 4000 4130 0 0 {name=l646 sig_type=std_logic lab=iref}
N 4020 4150 4000 4150 {}
C {devices/lab_pin.sym} 4000 4150 0 0 {name=l647 sig_type=std_logic lab=sp_t53}
N 4020 4170 4000 4170 {}
C {devices/lab_pin.sym} 4000 4170 0 0 {name=l648 sig_type=std_logic lab=sn_t53}
N 4020 4190 4000 4190 {}
C {devices/lab_pin.sym} 4000 4190 0 0 {name=l649 sig_type=std_logic lab=vss}
N 4020 4210 4000 4210 {}
C {devices/lab_pin.sym} 4000 4210 0 0 {name=l650 sig_type=std_logic lab=outp}
N 4020 4230 4000 4230 {}
C {devices/lab_pin.sym} 4000 4230 0 0 {name=l651 sig_type=std_logic lab=outn}
C {driver.sym} 4800 3900 0 0 {name=xdrv_t54}
N 4720 3910 4700 3910 {}
C {devices/lab_pin.sym} 4700 3910 0 0 {name=l652 sig_type=std_logic lab=t54}
N 4720 3930 4700 3930 {}
C {devices/lab_pin.sym} 4700 3930 0 0 {name=l653 sig_type=std_logic lab=vdd}
N 4720 3950 4700 3950 {}
C {devices/lab_pin.sym} 4700 3950 0 0 {name=l654 sig_type=std_logic lab=vss}
N 4880 3910 4900 3910 {}
C {devices/lab_pin.sym} 4900 3910 2 0 {name=l655 sig_type=std_logic lab=sp_t54}
N 4880 3930 4900 3930 {}
C {devices/lab_pin.sym} 4900 3930 2 0 {name=l656 sig_type=std_logic lab=sn_t54}
C {elem_16.sym} 4800 4100 0 0 {name=xel_t54}
N 4720 4110 4700 4110 {}
C {devices/lab_pin.sym} 4700 4110 0 0 {name=l657 sig_type=std_logic lab=vbn}
N 4720 4130 4700 4130 {}
C {devices/lab_pin.sym} 4700 4130 0 0 {name=l658 sig_type=std_logic lab=iref}
N 4720 4150 4700 4150 {}
C {devices/lab_pin.sym} 4700 4150 0 0 {name=l659 sig_type=std_logic lab=sp_t54}
N 4720 4170 4700 4170 {}
C {devices/lab_pin.sym} 4700 4170 0 0 {name=l660 sig_type=std_logic lab=sn_t54}
N 4720 4190 4700 4190 {}
C {devices/lab_pin.sym} 4700 4190 0 0 {name=l661 sig_type=std_logic lab=vss}
N 4720 4210 4700 4210 {}
C {devices/lab_pin.sym} 4700 4210 0 0 {name=l662 sig_type=std_logic lab=outp}
N 4720 4230 4700 4230 {}
C {devices/lab_pin.sym} 4700 4230 0 0 {name=l663 sig_type=std_logic lab=outn}
C {driver.sym} 5500 3900 0 0 {name=xdrv_t55}
N 5420 3910 5400 3910 {}
C {devices/lab_pin.sym} 5400 3910 0 0 {name=l664 sig_type=std_logic lab=t55}
N 5420 3930 5400 3930 {}
C {devices/lab_pin.sym} 5400 3930 0 0 {name=l665 sig_type=std_logic lab=vdd}
N 5420 3950 5400 3950 {}
C {devices/lab_pin.sym} 5400 3950 0 0 {name=l666 sig_type=std_logic lab=vss}
N 5580 3910 5600 3910 {}
C {devices/lab_pin.sym} 5600 3910 2 0 {name=l667 sig_type=std_logic lab=sp_t55}
N 5580 3930 5600 3930 {}
C {devices/lab_pin.sym} 5600 3930 2 0 {name=l668 sig_type=std_logic lab=sn_t55}
C {elem_16.sym} 5500 4100 0 0 {name=xel_t55}
N 5420 4110 5400 4110 {}
C {devices/lab_pin.sym} 5400 4110 0 0 {name=l669 sig_type=std_logic lab=vbn}
N 5420 4130 5400 4130 {}
C {devices/lab_pin.sym} 5400 4130 0 0 {name=l670 sig_type=std_logic lab=iref}
N 5420 4150 5400 4150 {}
C {devices/lab_pin.sym} 5400 4150 0 0 {name=l671 sig_type=std_logic lab=sp_t55}
N 5420 4170 5400 4170 {}
C {devices/lab_pin.sym} 5400 4170 0 0 {name=l672 sig_type=std_logic lab=sn_t55}
N 5420 4190 5400 4190 {}
C {devices/lab_pin.sym} 5400 4190 0 0 {name=l673 sig_type=std_logic lab=vss}
N 5420 4210 5400 4210 {}
C {devices/lab_pin.sym} 5400 4210 0 0 {name=l674 sig_type=std_logic lab=outp}
N 5420 4230 5400 4230 {}
C {devices/lab_pin.sym} 5400 4230 0 0 {name=l675 sig_type=std_logic lab=outn}
C {driver.sym} 600 4500 0 0 {name=xdrv_t56}
N 520 4510 500 4510 {}
C {devices/lab_pin.sym} 500 4510 0 0 {name=l676 sig_type=std_logic lab=t56}
N 520 4530 500 4530 {}
C {devices/lab_pin.sym} 500 4530 0 0 {name=l677 sig_type=std_logic lab=vdd}
N 520 4550 500 4550 {}
C {devices/lab_pin.sym} 500 4550 0 0 {name=l678 sig_type=std_logic lab=vss}
N 680 4510 700 4510 {}
C {devices/lab_pin.sym} 700 4510 2 0 {name=l679 sig_type=std_logic lab=sp_t56}
N 680 4530 700 4530 {}
C {devices/lab_pin.sym} 700 4530 2 0 {name=l680 sig_type=std_logic lab=sn_t56}
C {elem_16.sym} 600 4700 0 0 {name=xel_t56}
N 520 4710 500 4710 {}
C {devices/lab_pin.sym} 500 4710 0 0 {name=l681 sig_type=std_logic lab=vbn}
N 520 4730 500 4730 {}
C {devices/lab_pin.sym} 500 4730 0 0 {name=l682 sig_type=std_logic lab=iref}
N 520 4750 500 4750 {}
C {devices/lab_pin.sym} 500 4750 0 0 {name=l683 sig_type=std_logic lab=sp_t56}
N 520 4770 500 4770 {}
C {devices/lab_pin.sym} 500 4770 0 0 {name=l684 sig_type=std_logic lab=sn_t56}
N 520 4790 500 4790 {}
C {devices/lab_pin.sym} 500 4790 0 0 {name=l685 sig_type=std_logic lab=vss}
N 520 4810 500 4810 {}
C {devices/lab_pin.sym} 500 4810 0 0 {name=l686 sig_type=std_logic lab=outp}
N 520 4830 500 4830 {}
C {devices/lab_pin.sym} 500 4830 0 0 {name=l687 sig_type=std_logic lab=outn}
C {driver.sym} 1300 4500 0 0 {name=xdrv_t57}
N 1220 4510 1200 4510 {}
C {devices/lab_pin.sym} 1200 4510 0 0 {name=l688 sig_type=std_logic lab=t57}
N 1220 4530 1200 4530 {}
C {devices/lab_pin.sym} 1200 4530 0 0 {name=l689 sig_type=std_logic lab=vdd}
N 1220 4550 1200 4550 {}
C {devices/lab_pin.sym} 1200 4550 0 0 {name=l690 sig_type=std_logic lab=vss}
N 1380 4510 1400 4510 {}
C {devices/lab_pin.sym} 1400 4510 2 0 {name=l691 sig_type=std_logic lab=sp_t57}
N 1380 4530 1400 4530 {}
C {devices/lab_pin.sym} 1400 4530 2 0 {name=l692 sig_type=std_logic lab=sn_t57}
C {elem_16.sym} 1300 4700 0 0 {name=xel_t57}
N 1220 4710 1200 4710 {}
C {devices/lab_pin.sym} 1200 4710 0 0 {name=l693 sig_type=std_logic lab=vbn}
N 1220 4730 1200 4730 {}
C {devices/lab_pin.sym} 1200 4730 0 0 {name=l694 sig_type=std_logic lab=iref}
N 1220 4750 1200 4750 {}
C {devices/lab_pin.sym} 1200 4750 0 0 {name=l695 sig_type=std_logic lab=sp_t57}
N 1220 4770 1200 4770 {}
C {devices/lab_pin.sym} 1200 4770 0 0 {name=l696 sig_type=std_logic lab=sn_t57}
N 1220 4790 1200 4790 {}
C {devices/lab_pin.sym} 1200 4790 0 0 {name=l697 sig_type=std_logic lab=vss}
N 1220 4810 1200 4810 {}
C {devices/lab_pin.sym} 1200 4810 0 0 {name=l698 sig_type=std_logic lab=outp}
N 1220 4830 1200 4830 {}
C {devices/lab_pin.sym} 1200 4830 0 0 {name=l699 sig_type=std_logic lab=outn}
C {driver.sym} 2000 4500 0 0 {name=xdrv_t58}
N 1920 4510 1900 4510 {}
C {devices/lab_pin.sym} 1900 4510 0 0 {name=l700 sig_type=std_logic lab=t58}
N 1920 4530 1900 4530 {}
C {devices/lab_pin.sym} 1900 4530 0 0 {name=l701 sig_type=std_logic lab=vdd}
N 1920 4550 1900 4550 {}
C {devices/lab_pin.sym} 1900 4550 0 0 {name=l702 sig_type=std_logic lab=vss}
N 2080 4510 2100 4510 {}
C {devices/lab_pin.sym} 2100 4510 2 0 {name=l703 sig_type=std_logic lab=sp_t58}
N 2080 4530 2100 4530 {}
C {devices/lab_pin.sym} 2100 4530 2 0 {name=l704 sig_type=std_logic lab=sn_t58}
C {elem_16.sym} 2000 4700 0 0 {name=xel_t58}
N 1920 4710 1900 4710 {}
C {devices/lab_pin.sym} 1900 4710 0 0 {name=l705 sig_type=std_logic lab=vbn}
N 1920 4730 1900 4730 {}
C {devices/lab_pin.sym} 1900 4730 0 0 {name=l706 sig_type=std_logic lab=iref}
N 1920 4750 1900 4750 {}
C {devices/lab_pin.sym} 1900 4750 0 0 {name=l707 sig_type=std_logic lab=sp_t58}
N 1920 4770 1900 4770 {}
C {devices/lab_pin.sym} 1900 4770 0 0 {name=l708 sig_type=std_logic lab=sn_t58}
N 1920 4790 1900 4790 {}
C {devices/lab_pin.sym} 1900 4790 0 0 {name=l709 sig_type=std_logic lab=vss}
N 1920 4810 1900 4810 {}
C {devices/lab_pin.sym} 1900 4810 0 0 {name=l710 sig_type=std_logic lab=outp}
N 1920 4830 1900 4830 {}
C {devices/lab_pin.sym} 1900 4830 0 0 {name=l711 sig_type=std_logic lab=outn}
C {driver.sym} 2700 4500 0 0 {name=xdrv_t59}
N 2620 4510 2600 4510 {}
C {devices/lab_pin.sym} 2600 4510 0 0 {name=l712 sig_type=std_logic lab=t59}
N 2620 4530 2600 4530 {}
C {devices/lab_pin.sym} 2600 4530 0 0 {name=l713 sig_type=std_logic lab=vdd}
N 2620 4550 2600 4550 {}
C {devices/lab_pin.sym} 2600 4550 0 0 {name=l714 sig_type=std_logic lab=vss}
N 2780 4510 2800 4510 {}
C {devices/lab_pin.sym} 2800 4510 2 0 {name=l715 sig_type=std_logic lab=sp_t59}
N 2780 4530 2800 4530 {}
C {devices/lab_pin.sym} 2800 4530 2 0 {name=l716 sig_type=std_logic lab=sn_t59}
C {elem_16.sym} 2700 4700 0 0 {name=xel_t59}
N 2620 4710 2600 4710 {}
C {devices/lab_pin.sym} 2600 4710 0 0 {name=l717 sig_type=std_logic lab=vbn}
N 2620 4730 2600 4730 {}
C {devices/lab_pin.sym} 2600 4730 0 0 {name=l718 sig_type=std_logic lab=iref}
N 2620 4750 2600 4750 {}
C {devices/lab_pin.sym} 2600 4750 0 0 {name=l719 sig_type=std_logic lab=sp_t59}
N 2620 4770 2600 4770 {}
C {devices/lab_pin.sym} 2600 4770 0 0 {name=l720 sig_type=std_logic lab=sn_t59}
N 2620 4790 2600 4790 {}
C {devices/lab_pin.sym} 2600 4790 0 0 {name=l721 sig_type=std_logic lab=vss}
N 2620 4810 2600 4810 {}
C {devices/lab_pin.sym} 2600 4810 0 0 {name=l722 sig_type=std_logic lab=outp}
N 2620 4830 2600 4830 {}
C {devices/lab_pin.sym} 2600 4830 0 0 {name=l723 sig_type=std_logic lab=outn}
C {driver.sym} 3400 4500 0 0 {name=xdrv_t60}
N 3320 4510 3300 4510 {}
C {devices/lab_pin.sym} 3300 4510 0 0 {name=l724 sig_type=std_logic lab=t60}
N 3320 4530 3300 4530 {}
C {devices/lab_pin.sym} 3300 4530 0 0 {name=l725 sig_type=std_logic lab=vdd}
N 3320 4550 3300 4550 {}
C {devices/lab_pin.sym} 3300 4550 0 0 {name=l726 sig_type=std_logic lab=vss}
N 3480 4510 3500 4510 {}
C {devices/lab_pin.sym} 3500 4510 2 0 {name=l727 sig_type=std_logic lab=sp_t60}
N 3480 4530 3500 4530 {}
C {devices/lab_pin.sym} 3500 4530 2 0 {name=l728 sig_type=std_logic lab=sn_t60}
C {elem_16.sym} 3400 4700 0 0 {name=xel_t60}
N 3320 4710 3300 4710 {}
C {devices/lab_pin.sym} 3300 4710 0 0 {name=l729 sig_type=std_logic lab=vbn}
N 3320 4730 3300 4730 {}
C {devices/lab_pin.sym} 3300 4730 0 0 {name=l730 sig_type=std_logic lab=iref}
N 3320 4750 3300 4750 {}
C {devices/lab_pin.sym} 3300 4750 0 0 {name=l731 sig_type=std_logic lab=sp_t60}
N 3320 4770 3300 4770 {}
C {devices/lab_pin.sym} 3300 4770 0 0 {name=l732 sig_type=std_logic lab=sn_t60}
N 3320 4790 3300 4790 {}
C {devices/lab_pin.sym} 3300 4790 0 0 {name=l733 sig_type=std_logic lab=vss}
N 3320 4810 3300 4810 {}
C {devices/lab_pin.sym} 3300 4810 0 0 {name=l734 sig_type=std_logic lab=outp}
N 3320 4830 3300 4830 {}
C {devices/lab_pin.sym} 3300 4830 0 0 {name=l735 sig_type=std_logic lab=outn}
C {driver.sym} 4100 4500 0 0 {name=xdrv_t61}
N 4020 4510 4000 4510 {}
C {devices/lab_pin.sym} 4000 4510 0 0 {name=l736 sig_type=std_logic lab=t61}
N 4020 4530 4000 4530 {}
C {devices/lab_pin.sym} 4000 4530 0 0 {name=l737 sig_type=std_logic lab=vdd}
N 4020 4550 4000 4550 {}
C {devices/lab_pin.sym} 4000 4550 0 0 {name=l738 sig_type=std_logic lab=vss}
N 4180 4510 4200 4510 {}
C {devices/lab_pin.sym} 4200 4510 2 0 {name=l739 sig_type=std_logic lab=sp_t61}
N 4180 4530 4200 4530 {}
C {devices/lab_pin.sym} 4200 4530 2 0 {name=l740 sig_type=std_logic lab=sn_t61}
C {elem_16.sym} 4100 4700 0 0 {name=xel_t61}
N 4020 4710 4000 4710 {}
C {devices/lab_pin.sym} 4000 4710 0 0 {name=l741 sig_type=std_logic lab=vbn}
N 4020 4730 4000 4730 {}
C {devices/lab_pin.sym} 4000 4730 0 0 {name=l742 sig_type=std_logic lab=iref}
N 4020 4750 4000 4750 {}
C {devices/lab_pin.sym} 4000 4750 0 0 {name=l743 sig_type=std_logic lab=sp_t61}
N 4020 4770 4000 4770 {}
C {devices/lab_pin.sym} 4000 4770 0 0 {name=l744 sig_type=std_logic lab=sn_t61}
N 4020 4790 4000 4790 {}
C {devices/lab_pin.sym} 4000 4790 0 0 {name=l745 sig_type=std_logic lab=vss}
N 4020 4810 4000 4810 {}
C {devices/lab_pin.sym} 4000 4810 0 0 {name=l746 sig_type=std_logic lab=outp}
N 4020 4830 4000 4830 {}
C {devices/lab_pin.sym} 4000 4830 0 0 {name=l747 sig_type=std_logic lab=outn}
C {driver.sym} 4800 4500 0 0 {name=xdrv_t62}
N 4720 4510 4700 4510 {}
C {devices/lab_pin.sym} 4700 4510 0 0 {name=l748 sig_type=std_logic lab=t62}
N 4720 4530 4700 4530 {}
C {devices/lab_pin.sym} 4700 4530 0 0 {name=l749 sig_type=std_logic lab=vdd}
N 4720 4550 4700 4550 {}
C {devices/lab_pin.sym} 4700 4550 0 0 {name=l750 sig_type=std_logic lab=vss}
N 4880 4510 4900 4510 {}
C {devices/lab_pin.sym} 4900 4510 2 0 {name=l751 sig_type=std_logic lab=sp_t62}
N 4880 4530 4900 4530 {}
C {devices/lab_pin.sym} 4900 4530 2 0 {name=l752 sig_type=std_logic lab=sn_t62}
C {elem_16.sym} 4800 4700 0 0 {name=xel_t62}
N 4720 4710 4700 4710 {}
C {devices/lab_pin.sym} 4700 4710 0 0 {name=l753 sig_type=std_logic lab=vbn}
N 4720 4730 4700 4730 {}
C {devices/lab_pin.sym} 4700 4730 0 0 {name=l754 sig_type=std_logic lab=iref}
N 4720 4750 4700 4750 {}
C {devices/lab_pin.sym} 4700 4750 0 0 {name=l755 sig_type=std_logic lab=sp_t62}
N 4720 4770 4700 4770 {}
C {devices/lab_pin.sym} 4700 4770 0 0 {name=l756 sig_type=std_logic lab=sn_t62}
N 4720 4790 4700 4790 {}
C {devices/lab_pin.sym} 4700 4790 0 0 {name=l757 sig_type=std_logic lab=vss}
N 4720 4810 4700 4810 {}
C {devices/lab_pin.sym} 4700 4810 0 0 {name=l758 sig_type=std_logic lab=outp}
N 4720 4830 4700 4830 {}
C {devices/lab_pin.sym} 4700 4830 0 0 {name=l759 sig_type=std_logic lab=outn}
C {driver.sym} 5500 4500 0 0 {name=xdrv_b0}
N 5420 4510 5400 4510 {}
C {devices/lab_pin.sym} 5400 4510 0 0 {name=l760 sig_type=std_logic lab=b0}
N 5420 4530 5400 4530 {}
C {devices/lab_pin.sym} 5400 4530 0 0 {name=l761 sig_type=std_logic lab=vdd}
N 5420 4550 5400 4550 {}
C {devices/lab_pin.sym} 5400 4550 0 0 {name=l762 sig_type=std_logic lab=vss}
N 5580 4510 5600 4510 {}
C {devices/lab_pin.sym} 5600 4510 2 0 {name=l763 sig_type=std_logic lab=sp_b0}
N 5580 4530 5600 4530 {}
C {devices/lab_pin.sym} 5600 4530 2 0 {name=l764 sig_type=std_logic lab=sn_b0}
C {elem_1.sym} 5500 4700 0 0 {name=xel_b0}
N 5420 4710 5400 4710 {}
C {devices/lab_pin.sym} 5400 4710 0 0 {name=l765 sig_type=std_logic lab=vbn}
N 5420 4730 5400 4730 {}
C {devices/lab_pin.sym} 5400 4730 0 0 {name=l766 sig_type=std_logic lab=iref}
N 5420 4750 5400 4750 {}
C {devices/lab_pin.sym} 5400 4750 0 0 {name=l767 sig_type=std_logic lab=sp_b0}
N 5420 4770 5400 4770 {}
C {devices/lab_pin.sym} 5400 4770 0 0 {name=l768 sig_type=std_logic lab=sn_b0}
N 5420 4790 5400 4790 {}
C {devices/lab_pin.sym} 5400 4790 0 0 {name=l769 sig_type=std_logic lab=vss}
N 5420 4810 5400 4810 {}
C {devices/lab_pin.sym} 5400 4810 0 0 {name=l770 sig_type=std_logic lab=outp}
N 5420 4830 5400 4830 {}
C {devices/lab_pin.sym} 5400 4830 0 0 {name=l771 sig_type=std_logic lab=outn}
C {driver.sym} 600 5100 0 0 {name=xdrv_b1}
N 520 5110 500 5110 {}
C {devices/lab_pin.sym} 500 5110 0 0 {name=l772 sig_type=std_logic lab=b1}
N 520 5130 500 5130 {}
C {devices/lab_pin.sym} 500 5130 0 0 {name=l773 sig_type=std_logic lab=vdd}
N 520 5150 500 5150 {}
C {devices/lab_pin.sym} 500 5150 0 0 {name=l774 sig_type=std_logic lab=vss}
N 680 5110 700 5110 {}
C {devices/lab_pin.sym} 700 5110 2 0 {name=l775 sig_type=std_logic lab=sp_b1}
N 680 5130 700 5130 {}
C {devices/lab_pin.sym} 700 5130 2 0 {name=l776 sig_type=std_logic lab=sn_b1}
C {elem_2.sym} 600 5300 0 0 {name=xel_b1}
N 520 5310 500 5310 {}
C {devices/lab_pin.sym} 500 5310 0 0 {name=l777 sig_type=std_logic lab=vbn}
N 520 5330 500 5330 {}
C {devices/lab_pin.sym} 500 5330 0 0 {name=l778 sig_type=std_logic lab=iref}
N 520 5350 500 5350 {}
C {devices/lab_pin.sym} 500 5350 0 0 {name=l779 sig_type=std_logic lab=sp_b1}
N 520 5370 500 5370 {}
C {devices/lab_pin.sym} 500 5370 0 0 {name=l780 sig_type=std_logic lab=sn_b1}
N 520 5390 500 5390 {}
C {devices/lab_pin.sym} 500 5390 0 0 {name=l781 sig_type=std_logic lab=vss}
N 520 5410 500 5410 {}
C {devices/lab_pin.sym} 500 5410 0 0 {name=l782 sig_type=std_logic lab=outp}
N 520 5430 500 5430 {}
C {devices/lab_pin.sym} 500 5430 0 0 {name=l783 sig_type=std_logic lab=outn}
C {driver.sym} 1300 5100 0 0 {name=xdrv_b2}
N 1220 5110 1200 5110 {}
C {devices/lab_pin.sym} 1200 5110 0 0 {name=l784 sig_type=std_logic lab=b2}
N 1220 5130 1200 5130 {}
C {devices/lab_pin.sym} 1200 5130 0 0 {name=l785 sig_type=std_logic lab=vdd}
N 1220 5150 1200 5150 {}
C {devices/lab_pin.sym} 1200 5150 0 0 {name=l786 sig_type=std_logic lab=vss}
N 1380 5110 1400 5110 {}
C {devices/lab_pin.sym} 1400 5110 2 0 {name=l787 sig_type=std_logic lab=sp_b2}
N 1380 5130 1400 5130 {}
C {devices/lab_pin.sym} 1400 5130 2 0 {name=l788 sig_type=std_logic lab=sn_b2}
C {elem_4.sym} 1300 5300 0 0 {name=xel_b2}
N 1220 5310 1200 5310 {}
C {devices/lab_pin.sym} 1200 5310 0 0 {name=l789 sig_type=std_logic lab=vbn}
N 1220 5330 1200 5330 {}
C {devices/lab_pin.sym} 1200 5330 0 0 {name=l790 sig_type=std_logic lab=iref}
N 1220 5350 1200 5350 {}
C {devices/lab_pin.sym} 1200 5350 0 0 {name=l791 sig_type=std_logic lab=sp_b2}
N 1220 5370 1200 5370 {}
C {devices/lab_pin.sym} 1200 5370 0 0 {name=l792 sig_type=std_logic lab=sn_b2}
N 1220 5390 1200 5390 {}
C {devices/lab_pin.sym} 1200 5390 0 0 {name=l793 sig_type=std_logic lab=vss}
N 1220 5410 1200 5410 {}
C {devices/lab_pin.sym} 1200 5410 0 0 {name=l794 sig_type=std_logic lab=outp}
N 1220 5430 1200 5430 {}
C {devices/lab_pin.sym} 1200 5430 0 0 {name=l795 sig_type=std_logic lab=outn}
C {driver.sym} 2000 5100 0 0 {name=xdrv_b3}
N 1920 5110 1900 5110 {}
C {devices/lab_pin.sym} 1900 5110 0 0 {name=l796 sig_type=std_logic lab=b3}
N 1920 5130 1900 5130 {}
C {devices/lab_pin.sym} 1900 5130 0 0 {name=l797 sig_type=std_logic lab=vdd}
N 1920 5150 1900 5150 {}
C {devices/lab_pin.sym} 1900 5150 0 0 {name=l798 sig_type=std_logic lab=vss}
N 2080 5110 2100 5110 {}
C {devices/lab_pin.sym} 2100 5110 2 0 {name=l799 sig_type=std_logic lab=sp_b3}
N 2080 5130 2100 5130 {}
C {devices/lab_pin.sym} 2100 5130 2 0 {name=l800 sig_type=std_logic lab=sn_b3}
C {elem_8.sym} 2000 5300 0 0 {name=xel_b3}
N 1920 5310 1900 5310 {}
C {devices/lab_pin.sym} 1900 5310 0 0 {name=l801 sig_type=std_logic lab=vbn}
N 1920 5330 1900 5330 {}
C {devices/lab_pin.sym} 1900 5330 0 0 {name=l802 sig_type=std_logic lab=iref}
N 1920 5350 1900 5350 {}
C {devices/lab_pin.sym} 1900 5350 0 0 {name=l803 sig_type=std_logic lab=sp_b3}
N 1920 5370 1900 5370 {}
C {devices/lab_pin.sym} 1900 5370 0 0 {name=l804 sig_type=std_logic lab=sn_b3}
N 1920 5390 1900 5390 {}
C {devices/lab_pin.sym} 1900 5390 0 0 {name=l805 sig_type=std_logic lab=vss}
N 1920 5410 1900 5410 {}
C {devices/lab_pin.sym} 1900 5410 0 0 {name=l806 sig_type=std_logic lab=outp}
N 1920 5430 1900 5430 {}
C {devices/lab_pin.sym} 1900 5430 0 0 {name=l807 sig_type=std_logic lab=outn}
C {dummy_cell.sym} 0 6300 0 0 {name=xdum_bin}
N -80 6310 -100 6310 {}
C {devices/lab_pin.sym} -100 6310 0 0 {name=l808 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 300 6300 0 0 {name=xdum_r0}
N 220 6310 200 6310 {}
C {devices/lab_pin.sym} 200 6310 0 0 {name=l809 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 600 6300 0 0 {name=xdum_r1}
N 520 6310 500 6310 {}
C {devices/lab_pin.sym} 500 6310 0 0 {name=l810 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 900 6300 0 0 {name=xdum_r2}
N 820 6310 800 6310 {}
C {devices/lab_pin.sym} 800 6310 0 0 {name=l811 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1200 6300 0 0 {name=xdum_r3}
N 1120 6310 1100 6310 {}
C {devices/lab_pin.sym} 1100 6310 0 0 {name=l812 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1500 6300 0 0 {name=xdum_r4}
N 1420 6310 1400 6310 {}
C {devices/lab_pin.sym} 1400 6310 0 0 {name=l813 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1800 6300 0 0 {name=xdum_r5}
N 1720 6310 1700 6310 {}
C {devices/lab_pin.sym} 1700 6310 0 0 {name=l814 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2100 6300 0 0 {name=xdum_r6}
N 2020 6310 2000 6310 {}
C {devices/lab_pin.sym} 2000 6310 0 0 {name=l815 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2400 6300 0 0 {name=xdum_r7}
N 2320 6310 2300 6310 {}
C {devices/lab_pin.sym} 2300 6310 0 0 {name=l816 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2700 6300 0 0 {name=xdum_r8}
N 2620 6310 2600 6310 {}
C {devices/lab_pin.sym} 2600 6310 0 0 {name=l817 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 3000 6300 0 0 {name=xdum_r9}
N 2920 6310 2900 6310 {}
C {devices/lab_pin.sym} 2900 6310 0 0 {name=l818 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 3300 6300 0 0 {name=xdum_r10}
N 3220 6310 3200 6310 {}
C {devices/lab_pin.sym} 3200 6310 0 0 {name=l819 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 0 6400 0 0 {name=xdum_r11}
N -80 6410 -100 6410 {}
C {devices/lab_pin.sym} -100 6410 0 0 {name=l820 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 300 6400 0 0 {name=xdum_r12}
N 220 6410 200 6410 {}
C {devices/lab_pin.sym} 200 6410 0 0 {name=l821 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 600 6400 0 0 {name=xdum_r13}
N 520 6410 500 6410 {}
C {devices/lab_pin.sym} 500 6410 0 0 {name=l822 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 900 6400 0 0 {name=xdum_r14}
N 820 6410 800 6410 {}
C {devices/lab_pin.sym} 800 6410 0 0 {name=l823 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1200 6400 0 0 {name=xdum_r15}
N 1120 6410 1100 6410 {}
C {devices/lab_pin.sym} 1100 6410 0 0 {name=l824 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1500 6400 0 0 {name=xdum_r16}
N 1420 6410 1400 6410 {}
C {devices/lab_pin.sym} 1400 6410 0 0 {name=l825 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1800 6400 0 0 {name=xdum_r17}
N 1720 6410 1700 6410 {}
C {devices/lab_pin.sym} 1700 6410 0 0 {name=l826 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2100 6400 0 0 {name=xdum_r18}
N 2020 6410 2000 6410 {}
C {devices/lab_pin.sym} 2000 6410 0 0 {name=l827 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2400 6400 0 0 {name=xdum_r19}
N 2320 6410 2300 6410 {}
C {devices/lab_pin.sym} 2300 6410 0 0 {name=l828 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2700 6400 0 0 {name=xdum_r20}
N 2620 6410 2600 6410 {}
C {devices/lab_pin.sym} 2600 6410 0 0 {name=l829 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 3000 6400 0 0 {name=xdum_r21}
N 2920 6410 2900 6410 {}
C {devices/lab_pin.sym} 2900 6410 0 0 {name=l830 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 3300 6400 0 0 {name=xdum_r22}
N 3220 6410 3200 6410 {}
C {devices/lab_pin.sym} 3200 6410 0 0 {name=l831 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 0 6500 0 0 {name=xdum_r23}
N -80 6510 -100 6510 {}
C {devices/lab_pin.sym} -100 6510 0 0 {name=l832 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 300 6500 0 0 {name=xdum_r24}
N 220 6510 200 6510 {}
C {devices/lab_pin.sym} 200 6510 0 0 {name=l833 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 600 6500 0 0 {name=xdum_r25}
N 520 6510 500 6510 {}
C {devices/lab_pin.sym} 500 6510 0 0 {name=l834 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 900 6500 0 0 {name=xdum_r26}
N 820 6510 800 6510 {}
C {devices/lab_pin.sym} 800 6510 0 0 {name=l835 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1200 6500 0 0 {name=xdum_r27}
N 1120 6510 1100 6510 {}
C {devices/lab_pin.sym} 1100 6510 0 0 {name=l836 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1500 6500 0 0 {name=xdum_r28}
N 1420 6510 1400 6510 {}
C {devices/lab_pin.sym} 1400 6510 0 0 {name=l837 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 1800 6500 0 0 {name=xdum_r29}
N 1720 6510 1700 6510 {}
C {devices/lab_pin.sym} 1700 6510 0 0 {name=l838 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2100 6500 0 0 {name=xdum_r30}
N 2020 6510 2000 6510 {}
C {devices/lab_pin.sym} 2000 6510 0 0 {name=l839 sig_type=std_logic lab=vss}
C {dummy_cell.sym} 2400 6500 0 0 {name=xdum_r31}
N 2320 6510 2300 6510 {}
C {devices/lab_pin.sym} 2300 6510 0 0 {name=l840 sig_type=std_logic lab=vss}
C {devices/iopin.sym} -400 0 0 0 {name=p841 lab=iref}
N -400 0 -420 0 {}
C {devices/lab_pin.sym} -420 0 0 0 {name=l842 sig_type=std_logic lab=iref}
C {devices/iopin.sym} -400 20 0 0 {name=p843 lab=vdd}
N -400 20 -420 20 {}
C {devices/lab_pin.sym} -420 20 0 0 {name=l844 sig_type=std_logic lab=vdd}
C {devices/iopin.sym} -400 40 0 0 {name=p845 lab=vss}
N -400 40 -420 40 {}
C {devices/lab_pin.sym} -420 40 0 0 {name=l846 sig_type=std_logic lab=vss}
C {devices/iopin.sym} -400 60 0 0 {name=p847 lab=outp}
N -400 60 -420 60 {}
C {devices/lab_pin.sym} -420 60 0 0 {name=l848 sig_type=std_logic lab=outp}
C {devices/iopin.sym} -400 80 0 0 {name=p849 lab=outn}
N -400 80 -420 80 {}
C {devices/lab_pin.sym} -420 80 0 0 {name=l850 sig_type=std_logic lab=outn}
C {devices/ipin.sym} -400 100 0 0 {name=p851 lab=t0}
N -400 100 -380 100 {}
C {devices/lab_pin.sym} -380 100 2 0 {name=l852 sig_type=std_logic lab=t0}
C {devices/ipin.sym} -400 120 0 0 {name=p853 lab=t1}
N -400 120 -380 120 {}
C {devices/lab_pin.sym} -380 120 2 0 {name=l854 sig_type=std_logic lab=t1}
C {devices/ipin.sym} -400 140 0 0 {name=p855 lab=t2}
N -400 140 -380 140 {}
C {devices/lab_pin.sym} -380 140 2 0 {name=l856 sig_type=std_logic lab=t2}
C {devices/ipin.sym} -400 160 0 0 {name=p857 lab=t3}
N -400 160 -380 160 {}
C {devices/lab_pin.sym} -380 160 2 0 {name=l858 sig_type=std_logic lab=t3}
C {devices/ipin.sym} -400 180 0 0 {name=p859 lab=t4}
N -400 180 -380 180 {}
C {devices/lab_pin.sym} -380 180 2 0 {name=l860 sig_type=std_logic lab=t4}
C {devices/ipin.sym} -400 200 0 0 {name=p861 lab=t5}
N -400 200 -380 200 {}
C {devices/lab_pin.sym} -380 200 2 0 {name=l862 sig_type=std_logic lab=t5}
C {devices/ipin.sym} -400 220 0 0 {name=p863 lab=t6}
N -400 220 -380 220 {}
C {devices/lab_pin.sym} -380 220 2 0 {name=l864 sig_type=std_logic lab=t6}
C {devices/ipin.sym} -400 240 0 0 {name=p865 lab=t7}
N -400 240 -380 240 {}
C {devices/lab_pin.sym} -380 240 2 0 {name=l866 sig_type=std_logic lab=t7}
C {devices/ipin.sym} -400 260 0 0 {name=p867 lab=t8}
N -400 260 -380 260 {}
C {devices/lab_pin.sym} -380 260 2 0 {name=l868 sig_type=std_logic lab=t8}
C {devices/ipin.sym} -400 280 0 0 {name=p869 lab=t9}
N -400 280 -380 280 {}
C {devices/lab_pin.sym} -380 280 2 0 {name=l870 sig_type=std_logic lab=t9}
C {devices/ipin.sym} -400 300 0 0 {name=p871 lab=t10}
N -400 300 -380 300 {}
C {devices/lab_pin.sym} -380 300 2 0 {name=l872 sig_type=std_logic lab=t10}
C {devices/ipin.sym} -400 320 0 0 {name=p873 lab=t11}
N -400 320 -380 320 {}
C {devices/lab_pin.sym} -380 320 2 0 {name=l874 sig_type=std_logic lab=t11}
C {devices/ipin.sym} -400 340 0 0 {name=p875 lab=t12}
N -400 340 -380 340 {}
C {devices/lab_pin.sym} -380 340 2 0 {name=l876 sig_type=std_logic lab=t12}
C {devices/ipin.sym} -400 360 0 0 {name=p877 lab=t13}
N -400 360 -380 360 {}
C {devices/lab_pin.sym} -380 360 2 0 {name=l878 sig_type=std_logic lab=t13}
C {devices/ipin.sym} -400 380 0 0 {name=p879 lab=t14}
N -400 380 -380 380 {}
C {devices/lab_pin.sym} -380 380 2 0 {name=l880 sig_type=std_logic lab=t14}
C {devices/ipin.sym} -400 400 0 0 {name=p881 lab=t15}
N -400 400 -380 400 {}
C {devices/lab_pin.sym} -380 400 2 0 {name=l882 sig_type=std_logic lab=t15}
C {devices/ipin.sym} -400 420 0 0 {name=p883 lab=t16}
N -400 420 -380 420 {}
C {devices/lab_pin.sym} -380 420 2 0 {name=l884 sig_type=std_logic lab=t16}
C {devices/ipin.sym} -400 440 0 0 {name=p885 lab=t17}
N -400 440 -380 440 {}
C {devices/lab_pin.sym} -380 440 2 0 {name=l886 sig_type=std_logic lab=t17}
C {devices/ipin.sym} -400 460 0 0 {name=p887 lab=t18}
N -400 460 -380 460 {}
C {devices/lab_pin.sym} -380 460 2 0 {name=l888 sig_type=std_logic lab=t18}
C {devices/ipin.sym} -400 480 0 0 {name=p889 lab=t19}
N -400 480 -380 480 {}
C {devices/lab_pin.sym} -380 480 2 0 {name=l890 sig_type=std_logic lab=t19}
C {devices/ipin.sym} -400 500 0 0 {name=p891 lab=t20}
N -400 500 -380 500 {}
C {devices/lab_pin.sym} -380 500 2 0 {name=l892 sig_type=std_logic lab=t20}
C {devices/ipin.sym} -400 520 0 0 {name=p893 lab=t21}
N -400 520 -380 520 {}
C {devices/lab_pin.sym} -380 520 2 0 {name=l894 sig_type=std_logic lab=t21}
C {devices/ipin.sym} -400 540 0 0 {name=p895 lab=t22}
N -400 540 -380 540 {}
C {devices/lab_pin.sym} -380 540 2 0 {name=l896 sig_type=std_logic lab=t22}
C {devices/ipin.sym} -400 560 0 0 {name=p897 lab=t23}
N -400 560 -380 560 {}
C {devices/lab_pin.sym} -380 560 2 0 {name=l898 sig_type=std_logic lab=t23}
C {devices/ipin.sym} -400 580 0 0 {name=p899 lab=t24}
N -400 580 -380 580 {}
C {devices/lab_pin.sym} -380 580 2 0 {name=l900 sig_type=std_logic lab=t24}
C {devices/ipin.sym} -400 600 0 0 {name=p901 lab=t25}
N -400 600 -380 600 {}
C {devices/lab_pin.sym} -380 600 2 0 {name=l902 sig_type=std_logic lab=t25}
C {devices/ipin.sym} -400 620 0 0 {name=p903 lab=t26}
N -400 620 -380 620 {}
C {devices/lab_pin.sym} -380 620 2 0 {name=l904 sig_type=std_logic lab=t26}
C {devices/ipin.sym} -400 640 0 0 {name=p905 lab=t27}
N -400 640 -380 640 {}
C {devices/lab_pin.sym} -380 640 2 0 {name=l906 sig_type=std_logic lab=t27}
C {devices/ipin.sym} -400 660 0 0 {name=p907 lab=t28}
N -400 660 -380 660 {}
C {devices/lab_pin.sym} -380 660 2 0 {name=l908 sig_type=std_logic lab=t28}
C {devices/ipin.sym} -400 680 0 0 {name=p909 lab=t29}
N -400 680 -380 680 {}
C {devices/lab_pin.sym} -380 680 2 0 {name=l910 sig_type=std_logic lab=t29}
C {devices/ipin.sym} -400 700 0 0 {name=p911 lab=t30}
N -400 700 -380 700 {}
C {devices/lab_pin.sym} -380 700 2 0 {name=l912 sig_type=std_logic lab=t30}
C {devices/ipin.sym} -400 720 0 0 {name=p913 lab=t31}
N -400 720 -380 720 {}
C {devices/lab_pin.sym} -380 720 2 0 {name=l914 sig_type=std_logic lab=t31}
C {devices/ipin.sym} -400 740 0 0 {name=p915 lab=t32}
N -400 740 -380 740 {}
C {devices/lab_pin.sym} -380 740 2 0 {name=l916 sig_type=std_logic lab=t32}
C {devices/ipin.sym} -400 760 0 0 {name=p917 lab=t33}
N -400 760 -380 760 {}
C {devices/lab_pin.sym} -380 760 2 0 {name=l918 sig_type=std_logic lab=t33}
C {devices/ipin.sym} -400 780 0 0 {name=p919 lab=t34}
N -400 780 -380 780 {}
C {devices/lab_pin.sym} -380 780 2 0 {name=l920 sig_type=std_logic lab=t34}
C {devices/ipin.sym} -400 800 0 0 {name=p921 lab=t35}
N -400 800 -380 800 {}
C {devices/lab_pin.sym} -380 800 2 0 {name=l922 sig_type=std_logic lab=t35}
C {devices/ipin.sym} -400 820 0 0 {name=p923 lab=t36}
N -400 820 -380 820 {}
C {devices/lab_pin.sym} -380 820 2 0 {name=l924 sig_type=std_logic lab=t36}
C {devices/ipin.sym} -400 840 0 0 {name=p925 lab=t37}
N -400 840 -380 840 {}
C {devices/lab_pin.sym} -380 840 2 0 {name=l926 sig_type=std_logic lab=t37}
C {devices/ipin.sym} -400 860 0 0 {name=p927 lab=t38}
N -400 860 -380 860 {}
C {devices/lab_pin.sym} -380 860 2 0 {name=l928 sig_type=std_logic lab=t38}
C {devices/ipin.sym} -400 880 0 0 {name=p929 lab=t39}
N -400 880 -380 880 {}
C {devices/lab_pin.sym} -380 880 2 0 {name=l930 sig_type=std_logic lab=t39}
C {devices/ipin.sym} -400 900 0 0 {name=p931 lab=t40}
N -400 900 -380 900 {}
C {devices/lab_pin.sym} -380 900 2 0 {name=l932 sig_type=std_logic lab=t40}
C {devices/ipin.sym} -400 920 0 0 {name=p933 lab=t41}
N -400 920 -380 920 {}
C {devices/lab_pin.sym} -380 920 2 0 {name=l934 sig_type=std_logic lab=t41}
C {devices/ipin.sym} -400 940 0 0 {name=p935 lab=t42}
N -400 940 -380 940 {}
C {devices/lab_pin.sym} -380 940 2 0 {name=l936 sig_type=std_logic lab=t42}
C {devices/ipin.sym} -400 960 0 0 {name=p937 lab=t43}
N -400 960 -380 960 {}
C {devices/lab_pin.sym} -380 960 2 0 {name=l938 sig_type=std_logic lab=t43}
C {devices/ipin.sym} -400 980 0 0 {name=p939 lab=t44}
N -400 980 -380 980 {}
C {devices/lab_pin.sym} -380 980 2 0 {name=l940 sig_type=std_logic lab=t44}
C {devices/ipin.sym} -400 1000 0 0 {name=p941 lab=t45}
N -400 1000 -380 1000 {}
C {devices/lab_pin.sym} -380 1000 2 0 {name=l942 sig_type=std_logic lab=t45}
C {devices/ipin.sym} -400 1020 0 0 {name=p943 lab=t46}
N -400 1020 -380 1020 {}
C {devices/lab_pin.sym} -380 1020 2 0 {name=l944 sig_type=std_logic lab=t46}
C {devices/ipin.sym} -400 1040 0 0 {name=p945 lab=t47}
N -400 1040 -380 1040 {}
C {devices/lab_pin.sym} -380 1040 2 0 {name=l946 sig_type=std_logic lab=t47}
C {devices/ipin.sym} -400 1060 0 0 {name=p947 lab=t48}
N -400 1060 -380 1060 {}
C {devices/lab_pin.sym} -380 1060 2 0 {name=l948 sig_type=std_logic lab=t48}
C {devices/ipin.sym} -400 1080 0 0 {name=p949 lab=t49}
N -400 1080 -380 1080 {}
C {devices/lab_pin.sym} -380 1080 2 0 {name=l950 sig_type=std_logic lab=t49}
C {devices/ipin.sym} -400 1100 0 0 {name=p951 lab=t50}
N -400 1100 -380 1100 {}
C {devices/lab_pin.sym} -380 1100 2 0 {name=l952 sig_type=std_logic lab=t50}
C {devices/ipin.sym} -400 1120 0 0 {name=p953 lab=t51}
N -400 1120 -380 1120 {}
C {devices/lab_pin.sym} -380 1120 2 0 {name=l954 sig_type=std_logic lab=t51}
C {devices/ipin.sym} -400 1140 0 0 {name=p955 lab=t52}
N -400 1140 -380 1140 {}
C {devices/lab_pin.sym} -380 1140 2 0 {name=l956 sig_type=std_logic lab=t52}
C {devices/ipin.sym} -400 1160 0 0 {name=p957 lab=t53}
N -400 1160 -380 1160 {}
C {devices/lab_pin.sym} -380 1160 2 0 {name=l958 sig_type=std_logic lab=t53}
C {devices/ipin.sym} -400 1180 0 0 {name=p959 lab=t54}
N -400 1180 -380 1180 {}
C {devices/lab_pin.sym} -380 1180 2 0 {name=l960 sig_type=std_logic lab=t54}
C {devices/ipin.sym} -400 1200 0 0 {name=p961 lab=t55}
N -400 1200 -380 1200 {}
C {devices/lab_pin.sym} -380 1200 2 0 {name=l962 sig_type=std_logic lab=t55}
C {devices/ipin.sym} -400 1220 0 0 {name=p963 lab=t56}
N -400 1220 -380 1220 {}
C {devices/lab_pin.sym} -380 1220 2 0 {name=l964 sig_type=std_logic lab=t56}
C {devices/ipin.sym} -400 1240 0 0 {name=p965 lab=t57}
N -400 1240 -380 1240 {}
C {devices/lab_pin.sym} -380 1240 2 0 {name=l966 sig_type=std_logic lab=t57}
C {devices/ipin.sym} -400 1260 0 0 {name=p967 lab=t58}
N -400 1260 -380 1260 {}
C {devices/lab_pin.sym} -380 1260 2 0 {name=l968 sig_type=std_logic lab=t58}
C {devices/ipin.sym} -400 1280 0 0 {name=p969 lab=t59}
N -400 1280 -380 1280 {}
C {devices/lab_pin.sym} -380 1280 2 0 {name=l970 sig_type=std_logic lab=t59}
C {devices/ipin.sym} -400 1300 0 0 {name=p971 lab=t60}
N -400 1300 -380 1300 {}
C {devices/lab_pin.sym} -380 1300 2 0 {name=l972 sig_type=std_logic lab=t60}
C {devices/ipin.sym} -400 1320 0 0 {name=p973 lab=t61}
N -400 1320 -380 1320 {}
C {devices/lab_pin.sym} -380 1320 2 0 {name=l974 sig_type=std_logic lab=t61}
C {devices/ipin.sym} -400 1340 0 0 {name=p975 lab=t62}
N -400 1340 -380 1340 {}
C {devices/lab_pin.sym} -380 1340 2 0 {name=l976 sig_type=std_logic lab=t62}
C {devices/ipin.sym} -400 1360 0 0 {name=p977 lab=b0}
N -400 1360 -380 1360 {}
C {devices/lab_pin.sym} -380 1360 2 0 {name=l978 sig_type=std_logic lab=b0}
C {devices/ipin.sym} -400 1380 0 0 {name=p979 lab=b1}
N -400 1380 -380 1380 {}
C {devices/lab_pin.sym} -380 1380 2 0 {name=l980 sig_type=std_logic lab=b1}
C {devices/ipin.sym} -400 1400 0 0 {name=p981 lab=b2}
N -400 1400 -380 1400 {}
C {devices/lab_pin.sym} -380 1400 2 0 {name=l982 sig_type=std_logic lab=b2}
C {devices/ipin.sym} -400 1420 0 0 {name=p983 lab=b3}
N -400 1420 -380 1420 {}
C {devices/lab_pin.sym} -380 1420 2 0 {name=l984 sig_type=std_logic lab=b3}
