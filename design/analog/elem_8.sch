v {xschem version=3.4.4 file_version=1.2
}
G {}
V {}
S {}
E {}
C {unit_cell.sym} 0 0 0 0 {name=xu0}
N -80 10 -100 10 {}
C {devices/lab_pin.sym} -100 10 0 0 {name=l1 sig_type=std_logic lab=vbn}
N -80 30 -100 30 {}
C {devices/lab_pin.sym} -100 30 0 0 {name=l2 sig_type=std_logic lab=vcas}
N -80 50 -100 50 {}
C {devices/lab_pin.sym} -100 50 0 0 {name=l3 sig_type=std_logic lab=sp}
N -80 70 -100 70 {}
C {devices/lab_pin.sym} -100 70 0 0 {name=l4 sig_type=std_logic lab=sn}
N -80 90 -100 90 {}
C {devices/lab_pin.sym} -100 90 0 0 {name=l5 sig_type=std_logic lab=vss}
N -80 110 -100 110 {}
C {devices/lab_pin.sym} -100 110 0 0 {name=l6 sig_type=std_logic lab=outp}
N -80 130 -100 130 {}
C {devices/lab_pin.sym} -100 130 0 0 {name=l7 sig_type=std_logic lab=outn}
C {unit_cell.sym} 260 0 0 0 {name=xu1}
N 180 10 160 10 {}
C {devices/lab_pin.sym} 160 10 0 0 {name=l8 sig_type=std_logic lab=vbn}
N 180 30 160 30 {}
C {devices/lab_pin.sym} 160 30 0 0 {name=l9 sig_type=std_logic lab=vcas}
N 180 50 160 50 {}
C {devices/lab_pin.sym} 160 50 0 0 {name=l10 sig_type=std_logic lab=sp}
N 180 70 160 70 {}
C {devices/lab_pin.sym} 160 70 0 0 {name=l11 sig_type=std_logic lab=sn}
N 180 90 160 90 {}
C {devices/lab_pin.sym} 160 90 0 0 {name=l12 sig_type=std_logic lab=vss}
N 180 110 160 110 {}
C {devices/lab_pin.sym} 160 110 0 0 {name=l13 sig_type=std_logic lab=outp}
N 180 130 160 130 {}
C {devices/lab_pin.sym} 160 130 0 0 {name=l14 sig_type=std_logic lab=outn}
C {unit_cell.sym} 520 0 0 0 {name=xu2}
N 440 10 420 10 {}
C {devices/lab_pin.sym} 420 10 0 0 {name=l15 sig_type=std_logic lab=vbn}
N 440 30 420 30 {}
C {devices/lab_pin.sym} 420 30 0 0 {name=l16 sig_type=std_logic lab=vcas}
N 440 50 420 50 {}
C {devices/lab_pin.sym} 420 50 0 0 {name=l17 sig_type=std_logic lab=sp}
N 440 70 420 70 {}
C {devices/lab_pin.sym} 420 70 0 0 {name=l18 sig_type=std_logic lab=sn}
N 440 90 420 90 {}
C {devices/lab_pin.sym} 420 90 0 0 {name=l19 sig_type=std_logic lab=vss}
N 440 110 420 110 {}
C {devices/lab_pin.sym} 420 110 0 0 {name=l20 sig_type=std_logic lab=outp}
N 440 130 420 130 {}
C {devices/lab_pin.sym} 420 130 0 0 {name=l21 sig_type=std_logic lab=outn}
C {unit_cell.sym} 780 0 0 0 {name=xu3}
N 700 10 680 10 {}
C {devices/lab_pin.sym} 680 10 0 0 {name=l22 sig_type=std_logic lab=vbn}
N 700 30 680 30 {}
C {devices/lab_pin.sym} 680 30 0 0 {name=l23 sig_type=std_logic lab=vcas}
N 700 50 680 50 {}
C {devices/lab_pin.sym} 680 50 0 0 {name=l24 sig_type=std_logic lab=sp}
N 700 70 680 70 {}
C {devices/lab_pin.sym} 680 70 0 0 {name=l25 sig_type=std_logic lab=sn}
N 700 90 680 90 {}
C {devices/lab_pin.sym} 680 90 0 0 {name=l26 sig_type=std_logic lab=vss}
N 700 110 680 110 {}
C {devices/lab_pin.sym} 680 110 0 0 {name=l27 sig_type=std_logic lab=outp}
N 700 130 680 130 {}
C {devices/lab_pin.sym} 680 130 0 0 {name=l28 sig_type=std_logic lab=outn}
C {unit_cell.sym} 0 200 0 0 {name=xu4}
N -80 210 -100 210 {}
C {devices/lab_pin.sym} -100 210 0 0 {name=l29 sig_type=std_logic lab=vbn}
N -80 230 -100 230 {}
C {devices/lab_pin.sym} -100 230 0 0 {name=l30 sig_type=std_logic lab=vcas}
N -80 250 -100 250 {}
C {devices/lab_pin.sym} -100 250 0 0 {name=l31 sig_type=std_logic lab=sp}
N -80 270 -100 270 {}
C {devices/lab_pin.sym} -100 270 0 0 {name=l32 sig_type=std_logic lab=sn}
N -80 290 -100 290 {}
C {devices/lab_pin.sym} -100 290 0 0 {name=l33 sig_type=std_logic lab=vss}
N -80 310 -100 310 {}
C {devices/lab_pin.sym} -100 310 0 0 {name=l34 sig_type=std_logic lab=outp}
N -80 330 -100 330 {}
C {devices/lab_pin.sym} -100 330 0 0 {name=l35 sig_type=std_logic lab=outn}
C {unit_cell.sym} 260 200 0 0 {name=xu5}
N 180 210 160 210 {}
C {devices/lab_pin.sym} 160 210 0 0 {name=l36 sig_type=std_logic lab=vbn}
N 180 230 160 230 {}
C {devices/lab_pin.sym} 160 230 0 0 {name=l37 sig_type=std_logic lab=vcas}
N 180 250 160 250 {}
C {devices/lab_pin.sym} 160 250 0 0 {name=l38 sig_type=std_logic lab=sp}
N 180 270 160 270 {}
C {devices/lab_pin.sym} 160 270 0 0 {name=l39 sig_type=std_logic lab=sn}
N 180 290 160 290 {}
C {devices/lab_pin.sym} 160 290 0 0 {name=l40 sig_type=std_logic lab=vss}
N 180 310 160 310 {}
C {devices/lab_pin.sym} 160 310 0 0 {name=l41 sig_type=std_logic lab=outp}
N 180 330 160 330 {}
C {devices/lab_pin.sym} 160 330 0 0 {name=l42 sig_type=std_logic lab=outn}
C {unit_cell.sym} 520 200 0 0 {name=xu6}
N 440 210 420 210 {}
C {devices/lab_pin.sym} 420 210 0 0 {name=l43 sig_type=std_logic lab=vbn}
N 440 230 420 230 {}
C {devices/lab_pin.sym} 420 230 0 0 {name=l44 sig_type=std_logic lab=vcas}
N 440 250 420 250 {}
C {devices/lab_pin.sym} 420 250 0 0 {name=l45 sig_type=std_logic lab=sp}
N 440 270 420 270 {}
C {devices/lab_pin.sym} 420 270 0 0 {name=l46 sig_type=std_logic lab=sn}
N 440 290 420 290 {}
C {devices/lab_pin.sym} 420 290 0 0 {name=l47 sig_type=std_logic lab=vss}
N 440 310 420 310 {}
C {devices/lab_pin.sym} 420 310 0 0 {name=l48 sig_type=std_logic lab=outp}
N 440 330 420 330 {}
C {devices/lab_pin.sym} 420 330 0 0 {name=l49 sig_type=std_logic lab=outn}
C {unit_cell.sym} 780 200 0 0 {name=xu7}
N 700 210 680 210 {}
C {devices/lab_pin.sym} 680 210 0 0 {name=l50 sig_type=std_logic lab=vbn}
N 700 230 680 230 {}
C {devices/lab_pin.sym} 680 230 0 0 {name=l51 sig_type=std_logic lab=vcas}
N 700 250 680 250 {}
C {devices/lab_pin.sym} 680 250 0 0 {name=l52 sig_type=std_logic lab=sp}
N 700 270 680 270 {}
C {devices/lab_pin.sym} 680 270 0 0 {name=l53 sig_type=std_logic lab=sn}
N 700 290 680 290 {}
C {devices/lab_pin.sym} 680 290 0 0 {name=l54 sig_type=std_logic lab=vss}
N 700 310 680 310 {}
C {devices/lab_pin.sym} 680 310 0 0 {name=l55 sig_type=std_logic lab=outp}
N 700 330 680 330 {}
C {devices/lab_pin.sym} 680 330 0 0 {name=l56 sig_type=std_logic lab=outn}
C {devices/ipin.sym} -400 0 0 0 {name=p57 lab=vbn}
N -400 0 -380 0 {}
C {devices/lab_pin.sym} -380 0 2 0 {name=l58 sig_type=std_logic lab=vbn}
C {devices/ipin.sym} -400 20 0 0 {name=p59 lab=vcas}
N -400 20 -380 20 {}
C {devices/lab_pin.sym} -380 20 2 0 {name=l60 sig_type=std_logic lab=vcas}
C {devices/ipin.sym} -400 40 0 0 {name=p61 lab=sp}
N -400 40 -380 40 {}
C {devices/lab_pin.sym} -380 40 2 0 {name=l62 sig_type=std_logic lab=sp}
C {devices/ipin.sym} -400 60 0 0 {name=p63 lab=sn}
N -400 60 -380 60 {}
C {devices/lab_pin.sym} -380 60 2 0 {name=l64 sig_type=std_logic lab=sn}
C {devices/iopin.sym} -400 80 0 0 {name=p65 lab=vss}
N -400 80 -420 80 {}
C {devices/lab_pin.sym} -420 80 0 0 {name=l66 sig_type=std_logic lab=vss}
C {devices/iopin.sym} -400 100 0 0 {name=p67 lab=outp}
N -400 100 -420 100 {}
C {devices/lab_pin.sym} -420 100 0 0 {name=l68 sig_type=std_logic lab=outp}
C {devices/iopin.sym} -400 120 0 0 {name=p69 lab=outn}
N -400 120 -420 120 {}
C {devices/lab_pin.sym} -420 120 0 0 {name=l70 sig_type=std_logic lab=outn}
